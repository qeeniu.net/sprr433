# Allegro board PROC109E2_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VBAT_XDS: length 4.1
  BOTTOM w0.178: 18.11,30.69 U37.68
  BOTTOM w0.33: 18.11,30.69 17.42,30 C208.1 R249.2
VBUS_DETECT: length 1.7
  TOP w0.135: R113.1 14.12,28.19 U20.4
VBUS_TYPEC: length 6.9
  TOP w0.254: J10.B9 17.27,16.49 J10.A4 17.27,18.5 v1(16.73,19.05) ; C70.1 20.43,19.81 ; v1(19.61,18.87) 19.77,18.71 J10.A9 19.77,16.49 J10.B4
  BOTTOM w0.381: J10.B9 17.32,16.97 ; J10.B4 19.72,16.97
  vias: v1(15.46,20.32) v1(15.46,19.05) v1(16.48,20.35) v1(19.68,23.88) v1(19.68,22.61) v1(19.84,21.59) v1(21.34,22.61)
VBUS_XDS_USB: length 43.5
  TOP w0.203: U24.10 U24.1
  TOP w0.254: 9.73,23.39 9.49,23.16 U24.10 ; v1(9.14,33.12) 8.06,32.04 2.58,32.04 TP27.1
  TOP w0.381: J20.1 6.48,22.38 6.81,22.71
  BOTTOM w0.33: U38.6 11.57,32.65 ; 10.16,32.51 11.32,31.35 U38.4
  BOTTOM w0.381: R222.2 R219.1
  BOTTOM w0.635: 15.49,43.41 R222.2
  BOTTOM w0.762: 15.49,43.41 14.07,41.99 10.77,41.99 9.37,40.59 9.37,36.68 10.16,35.89 10.16,34.14 v1(9.14,33.12) 9.14,31.37 11.15,29.36 11.15,25.63 v1(9.35,23.83) v1(8.08,23.83)
VCC3V3_TA: length 96.8
  TOP w0.178: v1(28.57,51.65) U4.2 29.37,51.95 29.54,52.12
  TOP w0.203: v1(5.08,41.96) 5.49,41.55 TP49.1
  TOP w0.33: U4.1 C5.1 v1(30.96,54.08)
  TOP w0.381: v1(10.4,54.99) v1(10.4,53.11) v1(10.4,51.23) v1(10.4,49.35) v1(10.4,47.47) ; v1(5.08,41.96) 4.65,41.96 v1(4.01,42.6) 4.01,43.56 4.31,43.86 U9.8 ; R34.2 26.37,48.81 v1(26.37,48.06) ; v1(26.39,51.1) 26.39,50.33 R28.2 ; U9.5 4.21,45.81 v1(3.94,46.08)
  TOP w0.508: R70.2 R67.2 R53.2 ; R17.2 26.39,51.8 v1(26.39,51.1) ; R34.2 R28.2
  L03_SIG1 w0.381: v1(10.4,47.47) 9.58,47.47 8.18,46.08 v1(3.94,46.08) 3.94,42.67 v1(4.01,42.6) ; v1(28.57,51.65) 28.02,51.1 v1(26.39,51.1) 19.08,51.1 18.78,51.41 15.29,51.41 14.99,51.1 13.67,51.1 12.85,50.29 12.24,50.29 11.3,49.35 v1(10.4,49.35) ; v1(4.01,42.6) 4.01,36.86 v1(6.55,34.32) ; v1(4.01,42.6) 4.45,42.6 v1(5.08,41.96)
  L04_PWR1 w0.381: v1(9.3,27.25) 9.27,27.23 v1(9.27,26.03) v1(7.49,26.03)
  BOTTOM w0.254: 23.75,54.36 23.85,54.26 U26.14 ; U26.15 23.72,54.76 23.6,54.64 ; C155.1 7.57,34.92 ; C146.1 7.57,35.81
  BOTTOM w0.33: U28.5 C88.1 33.45,52.38 ; C85.1 22.43,53.39 v1(22.53,53.29)
  BOTTOM w0.381: v1(9.3,27.25) 9.3,26.68 9.27,26.66 v1(9.27,26.03) 8.44,26.03 C243.1 8.33,26.03 v1(7.49,26.03) ; R209.2 v1(10.4,47.47)
  BOTTOM w0.508: R186.1 v1(10.4,53.11) 11.84,53.11 12.07,52.88 R187.1 ; R182.1 12.07,54.63 11.71,54.99 v1(10.4,54.99) R178.1 ; R189.2 v1(10.4,51.23) 11.63,51.23 12.07,50.79 R196.2 ; R202.2 12.07,48.99 11.71,49.35 v1(10.4,49.35) R197.2 ; 33.45,52.38 32.65,52.38 v1(30.96,54.08) ; v1(26.37,48.06) 24.94,49.49 R191.2
VCC3V3_XDS: length 98.4
  TOP w0.254: TP35.1 37.57,15.19 v1(37.57,19.41) ; R108.2 27.52,30.84 27.28,30.61 v1(27.28,30.1) ; C44.1 U16.7 ; R109.2 v1(29.84,31.62)
  TOP w0.33: v1(25.07,34.14) C44.1 ; U25.16 68.09,24.14 68.44,24.49 68.44,24.8 C60.1 68.33,24.94 68.12,24.94 v1(67.85,24.67)
  TOP w0.381: R100.2 v1(23.52,33.12) ; 38.86,33.48 41.07,31.27 41.07,22.91 v1(37.57,19.41) ; 25.43,27.86 25.22,27.66 v1(25.22,26.42) ; R98.2 v1(20.5,33.12) ; R99.2 v1(22.05,33.12) ; R101.2 v1(24.99,33.12)
  L05_GND2 w0.381: v1(67.85,24.67) 67.85,23.64 66.52,22.3 59.29,22.3 v1(58.81,21.82)
  BOTTOM w0.178: C191.1 35.81,31.09 35.81,31.09 U37.28 ; 35.75,35.89 35.75,35.89 U37.16 ; U37.122 30.7,42.24 v1(30.7,42.24) ; v1(17.78,39.7) 17.78,39.66 17.96,39.49 U37.90 ; U37.52 25.5,26.87 25.63,26.75 ; 35.94,39.19 35.84,39.09 U37.8 ; 17.73,31.09 U37.69 ; C180.1 36.08,31.89 U37.26 ; 30.71,26.77 30.7,26.78 U37.39 ; U37.47 27.5,28.9 27.55,28.95 27.55,29.82 v1(27.28,30.1) ; v1(22.02,44.73) 22.3,44.45 U37.101 ; U42.8 C260.1 ; U37.79 17.94,35.09 ; 27.1,44.45 U37.113 ; C121.1 36.67,39.49 U37.7 ; U37.51 25.9,26.9
  BOTTOM w0.254: 17.73,31.09 17.04,31.78 v1(17.04,32.28) ; 14.82,32.65 14.39,32.65 U38.1 ; v1(37.57,19.41) C262.1 36.44,18.81 36.23,19.02 U45.16
  BOTTOM w0.33: 25.9,26.9 26.09,26.72 C242.1 25.5,26.14 v1(25.22,26.42) ; v1(15.88,34.43) 16.47,35.03 C154.1 17.88,35.03 17.94,35.09 ; v1(36.98,35.86) 36.98,35.87 C151.1 36.4,35.89 35.75,35.89 ; v1(17.04,32.28) C181.1 C182.1 15.35,32.97 15.8,33.43 R246.1 ; v1(27.51,45.24) 27.51,45.24 C104.1 26.95,44.6 27.1,44.45 ; v1(58.81,21.82) 58.87,21.88 64.9,21.88 65.2,21.58 C260.1 ; 30.71,26.77 C240.1 31.45,25.96 31.62,26.14 v1(31.62,26.72) ; R235.1 38.44,40.06 v1(36.68,40.06) C121.1
  BOTTOM w0.381: v1(15.93,28.09) 15.73,28.09 15.35,28.47 R249.1
  vias: v1(14.61,34.43) v1(14.61,33.16) v1(36.14,30.48) v1(36.17,32.72)
VCC_5V0_CAN: length 4.2
  TOP w0.203: v1(165.84,22.66) 164.92,22.66 TP50.1
  BOTTOM w0.254: v1(165.84,22.66) R270.2
  BOTTOM w0.33: R270.2 C257.1 U44.3
VDD_1V1: length 25.7
  TOP w0.254: U19.39 138.18,24.59 137.51,23.92 C61.1 138.06,23.45 v1(138.07,23.47) ; v1(133.99,48.25) 133.99,48.23 133.98,48.23 C19.1 134.64,47.69 134.78,47.83 U7.31 ; C55.1 v1(144.35,28.78) U19.6 ; v1(133.99,29.2) 133.99,29.18 133.98,29.18 C56.1 134.64,28.64 134.78,28.78 U19.31 ; v1(138.07,42.49) 137.52,42.49 C34.1 137.51,42.89 138.18,43.57 U7.39 ; U7.6 v1(144.35,47.83) C17.1
  TOP w0.381: TP30.1 125.19,28.46 v1(125.19,27.25)
  BOTTOM w0.229: U39.9 125.49,30.29 125.73,30.05 ; 125.6,29.67 125.48,29.79 U39.10
  BOTTOM w0.254: C113.1 138.02,42.44 v1(138.07,42.49) ; C97.1 133.96,48.23 v1(133.99,48.25)
  BOTTOM w0.33: C228.1 134,28.62 C56.1 133.98,29.19 v1(133.99,29.2) ; v1(138.07,23.47) 138,23.39 C256.1 ; C229.1 126.19,27.49 ; C96.1 144.34,47.83 v1(144.35,47.83) C17.1 ; C98.1 133.96,46.62 C97.1 ; C55.1 v1(144.35,28.78) 144.34,28.78 C217.1
  BOTTOM w0.508: C222.1 125.7,28.63
  vias: v1(125.19,25.98) v1(126.46,25.98)
VDD_1V1_SS: length 1.7
  BOTTOM w0.203: C183.1 126.1,31.29 U39.7
VDD_1V8: length 84.1
  TOP w0.203: v1(19.94,47.93) 19.94,49.6 22.92,52.58 23.55,52.58 23.83,52.3 24.85,52.3 25.21,52.65 26.9,52.65 29.9,55.66 30.73,55.66 31.29,55.09 32.33,55.09 33.24,55.99 37.83,55.99 40.82,53.01 63.58,53.01 TP5.1
  TOP w0.254: v1(66.17,51.31) 66.17,50.93 R30.2 65.1,51.19 v1(65.1,51.32) 64.69,51.32 R29.2 ; C30.2 76.61,41.94 76.87,41.67 U11.5
  TOP w0.305: U18.F14 79.35,32.4 v2(79.35,32.84)
  TOP w0.33: v1(77.37,42.47) 77.37,42.49 77.04,42.82 C30.2
  TOP w0.381: v1(92.18,30.56) v1(92.99,30.56)
  L03_SIG1 w0.152: v2(79.35,32.84) 78.7,33.49 77.44,33.49 77.33,33.38
  L03_SIG1 w0.254: 77.33,33.38 73.11,33.38 72.71,33.78 71.35,33.78 68.88,31.32 v1(68.3,31.32)
  L03_SIG1 w0.381: v1(66.17,51.31) 65.11,51.31 v1(65.1,51.32)
  L04_PWR1 w0.254: v1(92.18,30.56) 92.04,30.69 92.04,33.94 91.31,34.67
  L04_PWR1 w0.508: v1(77.06,41.05) 77.06,42.16 v1(77.37,42.47)
  BOTTOM w0.135: v1(91.72,28.4) v1(92.99,28.4)
  BOTTOM w0.305: v2(79.35,32.84) 79.15,32.84 78.63,33.36 78.63,33.36 C162.1
  BOTTOM w0.381: FB2.1 78.09,41.74 v1(77.37,42.47) 77.37,43.22 FB1.1 ; R198.1 v1(19.94,47.93)
  BOTTOM w0.508: v1(77.06,41.05) 77.14,41.12 FB2.1
  vias: v1(64.9,52.58) v1(66.17,52.58) v1(68.76,25.45)
VDD_1V8_CT: length 3.8
  BOTTOM w0.254: U27.5 17.74,57.82 18.71,58.79 C80.1
VDD_1V8_ENABLE: length 31.4
  TOP w0.254: R31.1 57.07,51.68 56.55,52.2 41.05,52.2 38.81,49.96 38.81,44.35 39.29,43.87 v1(42.55,43.87) 42.79,44.11 U10.8
  BOTTOM w0.381: R224.1 v1(42.55,43.87)
VDD_1V8_R: length 1
  TOP w0.33: 62.61,48.25 U5.1 ; C20.1 64.67,48.36
VDD_1V8_SENSE: length 5.9
  BOTTOM w0.135: U27.10 19.57,53.08 19.94,52.71 R198.2 R199.1
VDD_2V5: length 19.9
  TOP w0.254: U19.9 v1(144.35,30.28) C53.1 ; C23.1 v1(144.35,46.33) U7.3 ; U19.3 v1(144.35,27.28) C58.1 ; U7.9 v1(144.35,49.33) C11.1
  TOP w0.381: R81.2 TP20.1 125.24,38.77 v1(125.24,37.97)
  BOTTOM w0.229: 125.6,40.39 125.48,40.51 U33.10 ; U33.9 125.49,41.01 125.73,40.77
  BOTTOM w0.33: C53.1 v1(144.35,30.28) ; C11.1 v1(144.35,49.33) ; v1(144.32,25.68) 144.68,26.03 C238.1 145.03,26.7 144.95,26.78 C58.1 v1(144.35,27.28) 144.32,27.25 C231.1 ; C107.1 145.03,45.67 144.91,45.8 144.95,45.84 C23.1 v1(144.35,46.33) 143.8,46.33 C100.1 ; C130.1 126.28,38.21
  BOTTOM w0.381: C107.1 144.6,45.09 v1(144.22,44.7)
  BOTTOM w0.508: C125.1 125.71,39.35 125.7,39.34
  vias: v1(125.24,36.7) v1(126.46,36.7)
VDD_2V5_PG: length 20.6
  TOP w0.203: R81.1 v1(115.7,39.37)
  TOP w0.254: R81.1 121.99,40.69 v1(121.34,41.35)
  BOTTOM w0.203: U39.5 121.35,31.79 118.26,34.87 117.4,34.87 115.7,36.58 v1(115.7,39.37) ; v1(121.34,41.35) 121.49,41.51 U33.3
VDD_2V5_SS: length 1.7
  BOTTOM w0.203: U33.7 126.1,42.01 C111.1
VDD_CORE_0V85: length 122.9
  TOP w0.102: U18.J10 80.89,30.34 81.38,29.86
  TOP w0.152: U18.N10 82.89,30.29 v2(83.37,29.82) 83.89,30.35 U18.R10 ; U18.R12 83.89,31.38 83.41,31.86
  TOP w0.178: v2(80.41,31.9) 80.7,31.59 U18.J12
  TOP w0.254: U18.V16 85.39,32.94 v2(85.36,32.9) ; v1(57.76,32.38) 57.76,31.78 C49.1 ; C48.1 56.62,32.26 v1(56.49,32.38) ; U18.L9 v2(81.89,29.39) ; v1(56.49,34.92) 56.49,36.58 TP23.1
  TOP w0.305: U18.J12 80.94,31.32 v2(81.4,31.32) 81.39,31.31 U18.K11 ; U18.G10 79.45,30.36 v2(79.41,30.4) 79.39,30.42 U18.F11 ; U18.K14 81.39,31.97 v2(81.46,31.9) 81.5,31.86 U18.L13 ; v2(82.39,31.9) U18.M14 ; U18.H8 80.41,29.38 v2(80.41,29.84) ; U18.R9 83.89,29.45 v2(83.94,29.41) 83.45,29.41 U18.P8 ; U18.N9 82.88,29.85 v2(82.88,29.39) 82.85,29.36 U18.M8 ; U18.P14 83.39,31.93 v2(83.37,31.9) 83.41,31.86 U18.R13 ; U18.H15 80.37,32.89 v2(79.87,32.89) ; v2(79.91,28.82) 79.89,28.8 U18.G6 U18.G5 ; U18.J9 81.38,29.86 v2(81.39,29.84) ; U18.J10 80.45,30.36 v2(80.41,30.4)
  TOP w0.508: C62.1 R130.1 v1(51.26,24.51) ; 55.33,34.8 55.08,34.55 R96.1 55.08,32.64 55.46,32.26
  L03_SIG1 w0.254: v1(23.22,56.11) 27.55,56.11 31.24,52.42 31.24,47.68 35.51,43.41 36.68,43.41 39.45,40.64 54.97,40.64 56.49,39.11 v1(56.49,34.92)
  L04_PWR1 w0.102: 84.4,32.38 83.92,31.9 v2(83.37,31.9)
  L04_PWR1 w0.254: v1(79.35,22.56) 78.84,22.56 78.26,21.97 72.77,21.97 70.84,23.9 70.84,25.27 69.93,26.19 63.7,26.19 63.37,25.86 52.6,25.86 v1(51.26,24.51)
  L04_PWR1 w0.305: 84.4,32.38 84.73,32.38 85.25,32.9 v2(85.36,32.9)
  BOTTOM w0.254: C187.1 81.56,31.8 v2(81.46,31.9) 81.4,31.9 v2(81.4,31.32)
  BOTTOM w0.305: v2(80.41,31.9) 80.51,31.8 C188.1 81.36,31.8 v2(81.46,31.9) ; C211.1 83.84,29.31 v2(83.94,29.41) ; C211.1 82.97,29.31 v2(82.88,29.39) 82.8,29.31 C212.1 81.98,29.31 v2(81.89,29.39) ; C211.1 83.32,29.77 v2(83.37,29.82) ; v2(81.39,29.84) 81.5,29.95 C199.1 ; C227.1 79.91,27.89 v2(79.91,28.82) 80.15,28.57 C214.1 ; C187.1 82.29,31.8 v2(82.39,31.9) 82.5,31.8 C186.1 83.26,31.8 v2(83.37,31.9) ; C200.1 80.47,29.9 v2(80.41,29.84) v2(80.41,30.4)
  BOTTOM w0.33: C163.1 79.96,32.98 v2(79.87,32.89) ; C227.1 79.67,27.89 79.65,27.88 79.65,27.88 79.36,27.59 79.36,27.58 79.2,27.42 79.2,27.15 ; v2(79.41,30.4) 79.47,30.34 C201.1 80.35,30.34 v2(80.41,30.4) ; v2(85.36,32.9) 85.36,33.01 C165.1
  BOTTOM w0.381: v1(74.8,35.76) 74.52,36.04 C136.1 74.52,36.47 v1(73.74,36.47) ; v1(80.11,23.09) 79.91,23.29 C255.1 79.15,22.75 v1(79.35,22.56)
  BOTTOM w0.508: R176.2 22.61,56.72 v1(23.22,56.11) ; C234.1 79.2,27.15
  vias: v1(56.49,33.66) v1(57.76,34.92) v1(57.76,33.66) v1(59.03,34.92) v1(59.03,33.66) v1(59.03,32.38) v1(60.3,34.92) v1(60.3,33.66) v1(60.3,32.38) v1(76.2,35.94) v1(80.14,25.27) v1(80.06,24.28) v1(80.8,22.56)
VDD_CORE_0V85_EN: length 36.4
  TOP w0.254: v1(48.94,25.25) 48.94,24.78 48.68,24.53 R127.1
  TOP w0.381: v1(62.41,50.9) R29.1 63.23,49.87 62.91,49.54 U5.3
  BOTTOM w0.203: v1(48.94,25.25) 48.94,28.13 49.99,29.18 49.99,31.62 60.19,41.82 60.19,49.7 61.39,50.9 v1(62.41,50.9)
VDD_CORE_0V85_FB: length 4.4
  TOP w0.254: C62.2 R130.2 R124.1 49.64,25.93 49.64,27.37 49.64,27.37 U21.2
VDD_CORE_0V85_H_SENSE: length 5.9
  TOP w0.135: v1(20.47,58.14) 21.3,58.14 R6.1
  BOTTOM w0.135: R175.2 21.28,58.14 v1(20.47,58.14) 19.68,57.35 19.68,55.26 19.5,55.08 U27.6
VDD_CORE_0V85_L_SENSE: length 5.1
  TOP w0.135: R6.2 20.82,57.06 v1(20.47,56.72)
  BOTTOM w0.135: R176.1 v1(20.47,56.72) 20.04,56.29 20.04,55.11 19.5,54.58 U27.7
VDD_CORE_0V85_PG: length 62
  TOP w0.254: R112.1 U21.8 ; Q3.3 v1(3.01,32.83)
  TOP w0.381: R112.1 43.37,28.87 42.8,29.44 v1(42.8,32.87)
  L03_SIG1 w0.381: v1(42.8,32.87) 41.25,32.87 38.57,35.54 38.57,39.89 36.82,41.64 32.27,41.64 31.5,40.87 27.37,40.87 26.97,41.26 21.53,41.26 21.24,40.98 15.39,40.98 15,41.37 12.72,41.37 7.11,35.76 7.11,33.9 6.6,33.4 3.59,33.4 v1(3.01,32.83)
VDD_CORE_0V85_R: length 3.8
  TOP w0.254: 53.85,32.26 53.32,31.73 C50.1
  TOP w0.508: 53.85,32.26 54.1,32.51 R96.2 54.1,34.42 53.72,34.8
VDD_CORE_0V85_SW: length 4.8
  TOP w0.254: 50.56,30.27 50.56,30.14 50.14,29.71 U21.6
  TOP w0.762: 50.56,30.27 L2.1
VDDA_1P8_USB0: length 6.8
  TOP w0.152: v2(85.36,32.33) 84.89,32.79 U18.U15
  TOP w0.254: TP47.1 v1(92.53,33.73)
  BOTTOM w0.127: C177.1 86.69,32.3
  BOTTOM w0.152: 86.69,32.3 86.35,31.95 85.73,31.95 v2(85.36,32.33)
  BOTTOM w0.254: FB5.2 90.56,32.57 91.24,33.25 91.62,33.25 92.1,33.73 v1(92.53,33.73)
  BOTTOM w0.33: C176.1 C177.1
VDDA_1V8: length 105.6
  TOP w0.254: TP40.1 34.14,56.69 v1(32.59,56.69)
  TOP w0.305: U18.H14 79.93,32.36 v2(79.89,32.33) ; v2(79.85,34.33) 79.82,34.36 U18.F18
  TOP w0.33: U1.5 31.91,57.94 32.57,57.28 C4.1 v1(32.59,56.69)
  TOP w0.381: R15.2 12.21,52.93 12.59,52.54 v1(12.82,52.54)
  L03_SIG1 w0.381: v1(12.82,52.54) 12.82,54.24 14.73,56.15 21.7,56.15 22.25,56.69 v1(32.59,56.69) 32.59,47.35 34.04,45.9 35.48,45.9 36.09,46.5 37.21,46.5 38.33,45.38 49.84,45.38 50.2,45.02 55.61,45.02 56.98,43.66 71.66,43.66 74.93,40.39 77.55,40.39 78.28,41.12 v1(80.59,41.12) 79.68,40.21 79.68,38.38 v1(79.96,38.1)
  L05_GND2 w0.203: v2(79.89,32.33) 80.27,32.71 80.27,33.46 79.85,33.88 v2(79.85,34.33)
  BOTTOM w0.305: v2(79.85,34.33) 79.69,34.33 79.05,34.97 79.05,35.14 78.7,35.48 C153.1
  BOTTOM w0.33: C153.1 C144.1 C135.1 78.7,37.19 79.33,37.81 ; 79.4,39.2 C126.1
  BOTTOM w0.381: 79.32,37.81 79.33,37.81 C126.1
  BOTTOM w0.508: v1(80.59,41.12) 79.7,41.12 FB2.2 79.69,40.22 79.71,40.21 79.33,39.83 C126.1
VDDA_3P3_USB0: length 12.8
  TOP w0.152: v2(84.42,32.85) 84.89,33.32 U18.U16
  TOP w0.254: v1(89.81,35.84) 90.09,36.12 TP45.1
  L03_SIG1 w0.254: v2(84.42,32.85) 84.48,32.85 84.97,33.34 86.4,33.34 88.9,35.84 v1(89.81,35.84)
  BOTTOM w0.152: v2(84.42,32.85) 84.42,32.86 84.85,33.3 C178.1
  BOTTOM w0.33: C156.1 87.59,35.06 87.27,34.75 C157.1
  BOTTOM w0.508: v1(89.81,35.84) 89.65,35.67 FB4.2 89,34.9 88.84,35.06 C156.1
VDDA_3V3: length 19.1
  TOP w0.102: v2(80.89,32.38) 81.12,32.6 81.13,32.6 U18.K15
  TOP w0.254: TP43.1 70.38,38.92 70.38,37.87 70.79,37.45 v1(70.79,37.44)
  L03_SIG1 w0.152: v1(70.79,37.44) 71.25,36.98 77.29,36.98 79.28,35 79.28,34.23 80.51,33 80.51,32.75 80.88,32.38 v2(80.89,32.38)
  BOTTOM w0.305: v2(80.89,32.38) 80.6,32.38 C174.1
  BOTTOM w0.33: FB3.2 C142.1
  BOTTOM w0.508: FB3.2 71.3,36.49 70.79,37 v1(70.79,37.44)
VDDA_ADC: length 18.9
  TOP w0.203: TP48.1 80.39,41.99 v1(80.39,42.62)
  TOP w0.305: U18.G17 U18.H17 80.41,33.88 v2(80.41,34.33)
  L03_SIG1 w0.203: v2(80.41,34.33) 80.74,34.66 80.74,36.09 81.11,36.46
  L03_SIG1 w0.381: v1(80.39,42.62) 81.45,41.56 81.45,40.6 80.79,39.94 80.79,39.2 81.11,38.88 81.11,36.46
  BOTTOM w0.203: 80.7,35.34 80.74,35.3 80.74,34.66 v2(80.41,34.33)
  BOTTOM w0.254: C147.1 80.56,35.48 80.7,35.34
  BOTTOM w0.33: v1(80.39,42.62) 81.06,42.62 81.39,42.29 81.39,41.97 C116.1 ; C147.1 C148.1
  BOTTOM w0.508: v1(80.39,42.62) 80.24,42.47 79.61,42.47 79.31,42.77 FB1.2 C109.1
VDDA_PLL0: length 14.3
  TOP w0.254: v1(91.06,27.13) 90.22,27.13 TP41.1
  TOP w0.305: v2(83.37,31.32) 83.32,31.36 U18.N12
  L03_SIG1 w0.102: v2(83.37,31.32) 83.77,30.91 84.84,30.91 85.2,30.55 85.54,30.55 85.75,30.76 86.39,30.76
  L03_SIG1 w0.254: 89.05,30.56 88.06,30.56 87.86,30.76 86.39,30.76
  L03_SIG1 w0.381: v1(90.3,30.56) v1(89.46,30.56) 89.05,30.56
  BOTTOM w0.254: v1(90.3,30.56) 90.3,29.65 ; v1(91.06,27.13) 91.06,28.61 90.26,29.41 FB7.2
  BOTTOM w0.305: C185.1 v2(83.37,31.32)
  BOTTOM w0.33: C206.1 87.96,29.8 87.95,29.79 C204.1
VDDA_PLL1: length 12.8
  TOP w0.305: U18.G9 79.88,29.84 v2(79.39,29.84)
  TOP w0.381: TP44.1 73.99,26.39 v1(74.96,27.36)
  L03_SIG1 w0.254: v2(79.39,29.84) 77.44,29.84 v1(74.96,27.36)
  BOTTOM w0.254: C210.1 79.37,29.84 v2(79.39,29.84) ; FB9.2 72.09,26.31 72.17,26.4 C241.1 73.49,26.4 73.52,26.37 C236.1 74.02,26.38 74.41,26.78 74.41,26.84 v1(74.96,27.36)
VDDA_PLL2: length 14.2
  TOP w0.254: v1(71.81,31.22) 72.62,31.22 TP46.1
  TOP w0.381: v2(79.42,31.32) 79.46,31.36 U18.G12
  L03_SIG1 w0.254: v2(79.42,31.32) 79.39,31.32 78.81,31.9 78.25,31.9 78.08,32.07 77.13,32.07 75.87,30.81 72.21,30.81 v1(71.81,31.22)
  BOTTOM w0.33: C194.1 73.76,30.7 73.31,31.15 C193.1 72.5,31.22 v1(71.81,31.22) 71.39,31.22 FB6.2
  BOTTOM w0.356: C184.1 78.87,31.52 79.07,31.32 v2(79.42,31.32)
VDDA_TEMP: length 19.2
  TOP w0.102: v2(80.41,31.32) 79.95,30.86 U18.G11
  TOP w0.254: U18.M11 v2(82.39,30.4) ; TP42.1 v1(71.88,29.34)
  L03_SIG1 w0.152: 77.55,31.71 78.01,31.71 78.25,31.47 78.54,31.47
  L03_SIG1 w0.254: 78.54,31.47 79.12,30.89 79.98,30.89 v2(80.41,31.32) 80.84,30.89 81.91,30.89 v2(82.39,30.4) ; v1(71.88,29.34) 72.8,30.25 76.09,30.25 77.55,31.71
  BOTTOM w0.254: C190.1 80.06,31.62 80.37,31.32 v2(80.41,31.32)
  BOTTOM w0.305: C198.1 82.55,30.56 v2(82.39,30.4)
  BOTTOM w0.33: C225.1 73.39,28.66 73.51,28.78 C224.1
  BOTTOM w0.508: FB8.2 71.87,28.5 72.03,28.66 C225.1
VDDC_1V2_XDS: length 37.8
  TOP w0.254: v1(33.86,43.89) 34.75,43.89 37.47,41.17 37.47,39.88 34.87,37.29 v1(18.06,37.29)
  BOTTOM w0.178: U37.87 18.16,38.29 ; U37.115 27.9,44.48
  BOTTOM w0.33: 18.16,38.29 17.82,38.29 C132.1 17.98,37.34 18.01,37.34 v1(18.06,37.29) ; v1(33.86,43.89) 33.86,44.44 33.14,45.15 C102.1 C105.1 28.1,44.67 27.9,44.48
VDDSHV_3V3: length 55.9
  TOP w0.152: U18.E7 78.89,28.93 78.59,29.23 78.59,29.24 78.47,29.36 ; U18.U8 84.41,29.84 v2(84.36,29.84) ; v2(78.44,29.39) 78.89,29.85 U18.E9 ; 83.94,33.86 v2(84.39,33.4) ; U18.M6 82.35,28.36 v2(81.89,28.82) ; U18.P6 83.85,28.82 v2(83.85,28.85)
  TOP w0.254: 78.39,32.3 78.33,32.3 U18.C13 ; v1(84.58,22.48) 84.58,23.09 TP52.1 ; U18.R17 83.94,33.86
  TOP w0.305: U18.U8 U18.U7 ; U18.L6 v2(81.89,28.82) ; U18.T17 v2(84.39,33.4) ; U18.D13 78.39,32.3 v2(78.43,32.33) 78.45,32.36 U18.E14 ; v2(84.94,31.32) 84.89,31.27 U18.U11 U18.T11 ; U18.E8 78.47,29.36 v2(78.44,29.39) ; v2(82.88,32.9) 82.88,33.35 U18.N16 U18.N17 ; v2(78.44,32.9) 78.48,32.86 U18.E15 ; U18.P5 U18.P6 ; U18.T8 84.39,29.6 84.36,29.63 v2(84.36,29.84)
  L03_SIG1 w0.33: v1(84.3,38.2) 84.3,37.66 84.64,37.32 84.64,34.32 84.39,34.08 v2(84.39,33.4)
  L04_PWR1 w0.152: v2(83.85,28.85) 83.95,28.85 84.36,29.27 v2(84.36,29.84)
  L04_PWR1 w0.254: v2(84.39,33.4) 84.84,33.4 ; v2(84.36,29.84) 84.83,29.84
  BOTTOM w0.178: v2(83.85,28.85) 83.94,28.85 84.29,29.21 C213.1
  BOTTOM w0.254: C205.1 85.21,31.32 v2(84.94,31.32) ; 84.45,26.25 84.45,26.14 84.46,26.13 ; v2(81.89,28.82) 81.89,28.69 82.25,28.34 82.57,28.34 82.71,28.19 83.54,28.19
  BOTTOM w0.305: v2(83.85,28.85) 83.85,28.13 84.45,27.53 84.45,26.25 C235.1 ; C203.1 85.27,29.85 85.17,29.85 85.16,29.84 v2(84.36,29.84) ; v2(81.89,28.82) 81.6,28.52 C215.1 ; C175.1 82.69,33.1 v2(82.88,32.9) 82.88,33.36 83.25,33.73 84.07,33.73 v2(84.39,33.4) 84.39,34.1 C158.1 84.39,34.34 84.39,35.65 C145.1 ; v2(78.44,29.39) 78.44,29.55 C202.1
  BOTTOM w0.33: C140.1 C141.1 C134.1 84.21,38.2 v1(84.3,38.2) ; C140.1 C133.1 84.61,37.89 v1(84.3,38.2) ; C140.1 C145.1 ; v1(84.3,38.2) v1(84.3,39.01)
  BOTTOM w0.381: C167.1 77.01,32.85 77.53,32.33 v2(78.43,32.33) 78.43,32.89 v2(78.44,32.9)
  BOTTOM w0.508: v1(84.58,22.48) 83.85,21.74 76.17,21.74 75.46,22.45 75.46,25.96 76.28,26.77
  vias: v1(85.6,22.48)
VDDSHV_SDIO: length 34.8
  TOP w0.305: U18.L17 U18.L16 81.89,32.95 v2(81.85,32.9) ; U18.J17 80.94,33.82 v2(81.41,33.82)
  TOP w0.381: v1(93.29,50.42) 93.29,50.41 R21.2 ; v1(88.67,51.64) 88.67,50.79 89.05,50.41 R19.2
  L03_SIG1 w0.254: v2(81.41,33.82) 81.41,33.35 v2(81.85,32.9)
  L04_PWR1 w0.381: v1(88.67,51.64) 86.16,51.64 81.38,46.86 v1(81.38,39.67)
  BOTTOM w0.203: C160.1 81.05,34.54 81.05,35.1 81.36,35.41 C143.1
  BOTTOM w0.33: C172.1 81.39,33.79 v2(81.41,33.82) 81.41,34.1 81.37,34.13 81.37,34.21 C160.1 ; v1(81.38,39.67) 81.38,38.62 80.54,37.78 80.54,36.69 C143.1
  BOTTOM w0.381: v1(88.67,51.64) 88.67,51.59 88.65,51.57 R194.2 R193.2 R192.2 92.75,50.96 v1(93.29,50.42)
BOARD_POWER_EN: length 5.2
  TOP w0.254: U10.1 43.43,42 43.29,41.87 43.29,40.52 42.3,39.53 R85.1 R84.2
BOOTMODE0: length 2.1
  TOP w0.135: R39.1 87.12,47.21 v1(87.12,46.51) 87.12,45.83 R55.2
  BOTTOM w0.135: v1(87.12,46.51) 87.13,46.51 R208.2
BOOTMODE0_R: length 48
  TOP w0.102: 84.2,36.7 84.2,36.53 83.95,36.27 83.95,35.91 U18.R21
  TOP w0.135: R55.1 87.12,44.84 v1(87.12,43.87) 87.12,41.68 84.78,39.34 84.78,37.71 84.2,37.13 84.2,36.7
  L03_SIG1 w0.121: v1(87.12,43.87) 89.43,41.56 94.14,41.56 94.68,42.1 96.66,42.1 97.1,41.66 99.67,41.66 100.41,42.39 104.14,42.39 105.94,40.6 111.16,40.6 114.55,43.99 114.55,44.68 v1(115.11,45.24)
  BOTTOM w0.135: v1(115.11,45.24) 115.11,45.8 116.14,46.82 117.16,46.82 117.41,46.57 U32.3
BOOTMODE1: length 2
  TOP w0.135: R56.2 88.52,46.52 v1(88.52,46.53) 88.52,46.53 R40.1
  BOTTOM w0.135: v1(88.52,46.53) 88.52,46.53 R207.2
BOOTMODE2: length 3.1
  TOP w0.135: v1(91.39,47.22) 91.38,47.21 R41.1
  BOTTOM w0.135: R215.2 91.33,45.83 90.68,46.48 R206.2 90.72,47.22 v1(91.39,47.22)
BOOTMODE2_R: length 59.8
  TOP w0.102: U18.T19 83.96,34.86 v2(83.94,34.89)
  L03_SIG1 w0.121: v1(112.57,45.21) 113.13,45.77 114.02,45.77 114.27,45.52 114.27,44.15 111.13,41 107.02,41 104.6,43.43 98.25,43.43 97.72,42.9 94.94,42.9 93.86,41.82 90.68,41.82 v1(89.97,42.53) 88.82,42.53 87.71,43.64 87.71,44.24 87.48,44.48 86.23,44.48 85.88,44.12 85.88,42.9 83.54,40.57 83.54,35.99 83.94,35.6 v2(83.94,34.89)
  BOTTOM w0.135: v1(89.97,42.53) 90.6,43.16 90.6,44.12 91.33,44.85 R215.1 ; v1(112.57,45.21) 112.57,47.96 113.79,49.17 U32.7
BOOTMODE3: length 63.3
  TOP w0.135: v1(33.71,50.66) 33.7,50.65 U4.21 ; R42.2 92.82,48.65 92.99,48.82 v1(92.99,48.85)
  L03_SIG1 w0.121: v1(92.99,48.85) 91.45,50.39 88.24,50.39 86.58,52.05 82.02,52.05 81.74,51.76 75.74,51.76 75.36,52.14 40.89,52.14 39.22,50.47 33.89,50.47 v1(33.71,50.66)
BOOTMODE4: length 64
  TOP w0.135: v1(92.14,45.82) 92.83,45.82 R59.2 ; U4.20 34.4,50.15 34.87,49.68 v1(35.59,49.68)
  L03_SIG1 w0.121: v1(35.59,49.68) 36.03,49.68 36.12,49.59 56.4,49.59 57.07,50.27 65.84,50.27 67.2,51.63 74.73,51.63 75.26,51.11 82.78,51.11 83.39,50.5 86.44,50.5 87.41,49.53 88.76,49.53 90.5,47.79 90.5,47.02 91.7,45.82 v1(92.14,45.82)
BOOTMODE5: length 61.5
  TOP w0.135: U4.19 33.7,49.65 v1(33.71,49.66) ; R57.2 89.92,45.85 v1(89.92,47.35)
  L03_SIG1 w0.121: v1(33.71,49.66) 34.29,49.07 39.24,49.07 39.49,49.32 56.71,49.32 57.28,49.89 65.89,49.89 67.38,51.38 74.38,51.38 74.9,50.85 82.68,50.85 83.57,49.96 85.47,49.96 87.25,48.18 88.5,48.18 89.33,47.35 v1(89.92,47.35)
BOOTMODE6: length 61.6
  TOP w0.135: 32.82,49.15 34.97,49.15 v1(35.66,48.46)
  L03_SIG1 w0.121: v1(87.84,47.68) 86.51,47.68 85.88,48.31 84.86,48.31 82.57,50.6 74.6,50.6 74.07,51.12 67.79,51.12 64.39,47.73 59.87,47.73 59,48.59 55.64,48.59 55.52,48.47 49.06,48.47 48.47,49.06 39.62,49.06 39.01,48.46 v1(35.66,48.46)
  BOTTOM w0.135: R217.2 87.71,45.8 87.84,45.94 v1(87.84,47.68)
BOOTMODE7: length 62.1
  TOP w0.135: U4.17 34.23,48.65 v1(34.32,48.56)
  L03_SIG1 w0.121: v1(34.32,48.56) 35.05,47.83 38.71,47.83 39.07,48.18 55.32,48.18 56.08,47.43 64.8,47.43 68.24,50.87 73.85,50.87 74.37,50.34 82.46,50.34 84.78,48.03 85.7,48.03 86.56,47.17 88.8,47.17 v1(89.43,46.53)
  BOTTOM w0.135: v1(89.43,46.53) 89.43,46.05 89.21,45.83 R216.2
BOOTMODE8: length 68.7
  TOP w0.135: U4.16 33.91,48.15 34.39,47.68 36.02,47.68 37.08,48.74 v1(37.08,50.01)
  L03_SIG1 w0.121: v1(95.02,45.82) 93.42,45.82 90.6,48.64 90.6,49.21 89.95,49.86 87.44,49.86 85.51,51.79 82.12,51.79 81.84,51.51 75.39,51.51 75.01,51.89 41.09,51.89 39.22,50.01 v1(37.08,50.01)
  BOTTOM w0.135: v1(95.02,45.82) 94.3,45.82 R214.2
BOOTMODE8_R: length 48.1
  TOP w0.102: v2(85.42,33.86) 84.92,34.36 U18.U18
  L03_SIG1 w0.121: v2(85.42,33.86) 86.18,33.86 91.59,39.27 v1(93.7,39.27) 104.93,39.27 105.89,40.23 111.23,40.23 v1(115.11,44.12)
  BOTTOM w0.135: R214.1 94.33,44.85 95.02,44.15 95.02,40.59 v1(93.7,39.27) ; v1(115.11,44.12) 114.55,44.68 114.55,45.79 115.87,47.1 117.89,47.1 118.01,47.22 U32.4
BOOTMODE9: length 64.1
  TOP w0.135: R58.2 91.36,45.82 v1(90.64,45.82) ; v1(34.72,46.91) 33.98,47.65 U4.15
  L03_SIG1 w0.121: v1(90.64,45.82) 85.69,45.82 84.36,47.15 84.36,48.09 82.43,50.02 73.2,50.02 72.63,50.6 68.78,50.6 65.35,47.17 63.78,47.17 62.97,46.36 56.03,46.36 55.32,47.08 43.6,47.08 42.88,47.79 39.23,47.79 38.79,47.35 35.16,47.35 v1(34.72,46.91)
BOOTMODE9_R: length 48.6
  TOP w0.102: U18.U20 84.61,35.64 84.61,36 85.02,36.4 85.02,36.7
  TOP w0.135: R58.1 v1(91.37,43.87) 90.73,43.23 89.84,43.23 85.6,38.99 85.6,37.28 85.02,36.7
  L03_SIG1 w0.121: v1(113.74,45.24) 113.74,43.97 111.03,41.26 107.36,41.26 104.9,43.71 98.17,43.71 97.61,43.15 94.74,43.15 93.66,42.07 92.27,42.07 91.37,42.97 v1(91.37,43.87)
  BOTTOM w0.135: U32.5 118.07,47.87 117.38,48.56 115.34,48.56 114.83,48.06 114.83,46.78 113.74,45.69 v1(113.74,45.24)
BOOTMODE10: length 2.1
  TOP w0.135: R60.2 94.29,46.5 94.28,46.51 v1(94.28,46.51) 94.29,46.52 R43.1
  BOTTOM w0.135: v1(94.28,46.51) 94.31,46.54 R205.2
BOOTMODE10_R: length 45.8
  TOP w0.102: U18.V20 85.71,35.68 85.71,36.15 86.27,36.7 86.41,36.7
  TOP w0.135: R60.1 94.28,44.84 v1(94.28,43.87) 94.28,43.05 93.31,42.08 91.81,42.08 90.4,40.67 88.95,40.67 87.45,39.17 87.45,37.74 86.41,36.7
  L03_SIG1 w0.121: v1(94.28,43.87) 94.71,43.44 97.52,43.44 98.04,43.97 105.23,43.97 106.91,42.29 111.33,42.29 v1(113.16,44.12)
  BOTTOM w0.135: v1(113.16,44.12) 113.16,47.81 114.18,48.83 117.76,48.83 118.07,48.52 U32.6
BOOTMODE11: length 2.1
  TOP w0.135: R61.2 95.81,45.83 v1(95.81,46.51) 95.81,46.52 R44.1
  BOTTOM w0.135: v1(95.81,46.51) 95.86,46.57 R204.2
BOOTMODE12: length 2.1
  TOP w0.135: R45.1 97.34,46.51 v1(97.33,46.51) 97.34,46.5 R62.2
  BOTTOM w0.135: R203.2 97.41,46.58 v1(97.33,46.51)
BOOTMODE14: length 2.6
  TOP w0.135: R586.2 v1(96.98,40.94) 97.21,41.17 R588.1
  BOTTOM w0.135: v1(96.98,40.94) 96.98,41.85 R589.2
BOOTMODE15: length 5.1
  TOP w0.135: R587.2 94.91,40.55 v1(94.49,40.98) 93.81,40.98 93.31,40.47 R590.1
  BOTTOM w0.135: R590.1 93.11,40.98 v1(94.49,40.98)
BOOTMODEON: length 4.6
  TOP w0.135: v1(35.51,51.44) 35.26,51.44 35.05,51.23 35.05,50.58 ; 35.05,50.58 R24.2 ; 35.05,50.58 34.51,50.58 33.94,51.15 U4.22
  BOTTOM w0.135: U28.4 v1(35.51,51.44)
BP_3V3: length 2.8
  TOP w0.135: R163.2 J5.1
BP_5V0: length 2.8
  TOP w0.135: R161.1 J5.2
BP_ADC0_AIN0: length 7.3
  TOP w0.135: J1.3 44.58,14.75 44.58,17.58 43.61,18.54 R143.1
BP_ADC0_AIN1: length 7.4
  TOP w0.135: J1.11 54.74,14.75 54.74,17.09 55.96,18.31 R152.1
BP_ADC0_AIN2: length 4.2
  TOP w0.135: R144.1 44.98,18.62 45.83,17.78 J1.6
BP_ADC0_AIN3: length 4.1
  TOP w0.135: R146.1 47.73,17.85 48.37,17.21 J1.8
BP_ADC0_AIN4: length 4
  TOP w0.135: R148.1 50.47,17.65 50.91,17.21 J1.10
BP_ADC0_AIN5: length 3.9
  TOP w0.135: R150.1 53.21,18.45 53.45,18.22 J1.12
BP_ADC0_AIN6: length 4.9
  TOP w0.135: R154.1 58.7,18.72 J1.14
BP_ADC0_AIN7: length 5
  TOP w0.135: R156.1 61.44,18.92 J1.16
BP_CONN_1_PORZ: length 27
  TOP w0.135: v1(26.26,57.84) 26.26,57.83 R8.1
  L03_SIG1 w0.127: v1(26.26,57.84) 27.76,57.84 29.02,59.09 36.23,59.09 37.66,60.52 49.57,60.52 J2.10
BP_CONN_2_PORZ: length 88.4
  TOP w0.135: v1(34.32,60.1) 34.3,60.09 R2.1
  L03_SIG1 w0.121: v1(34.32,60.1) 36.14,60.1 37.34,61.29 75.11,61.29 80.04,56.36 83.74,56.36 84.65,55.46 97.2,55.46 97.54,55.12 100.33,55.12 101.52,56.31 101.52,58.26 104.6,61.34 112.25,61.34 J6.10
BUFF_ENABLE: length 5.4
  BOTTOM w0.135: U29.4 127.3,48.05 125.82,46.57 U32.22
CAP_VDDS0: length 1.1
  TOP w0.381: v2(78.44,30.9) 78.39,30.95 U18.D12
  BOTTOM w0.356: v2(78.44,30.9) 78.35,30.82 C192.1
CAP_VDDS1: length 1.5
  TOP w0.381: v2(82.39,27.9) 82.44,27.86 U18.N5
  BOTTOM w0.381: v2(82.39,27.9) 82.39,27.59 C233.1
CAP_VDDS2: length 1.3
  TOP w0.102: U18.U9 84.87,29.86 84.61,30.12 84.61,30.15 v2(84.36,30.4)
  BOTTOM w0.381: v2(84.36,30.4) 84.18,30.58 C196.1
CAP_VDDS3: length 1
  TOP w0.381: v2(83.86,32.93) 83.86,33.32 U18.R16
  BOTTOM w0.356: C173.1 83.66,33.12 v2(83.86,32.93)
CAP_VDDS4: length 2
  TOP w0.381: U18.N18 83.33,34.36 v2(83.37,34.33)
  BOTTOM w0.254: C149.1 83.26,35.45 82.93,35.12 82.93,34.72 83.32,34.33 v2(83.37,34.33)
CAP_VDDS5: length 2.7
  TOP w0.381: U18.M18 v2(82.39,33.82)
  BOTTOM w0.203: C150.1 82.16,35.46 82.04,35.34 82.04,34.73 82.39,34.37 v2(82.39,33.82)
CAP_VDDS_MCU: length 1.6
  TOP w0.152: v2(77.86,29.39) 78.33,29.86 U18.D9
  BOTTOM w0.33: C223.1 77.24,28.98 77.65,29.39 v2(77.86,29.39)
CORE_0V85_CT: length 2.9
  BOTTOM w0.254: C82.1 15.54,57.71 16.24,57.01 U27.2
CPSW_RGMII1_RD0: length 33.1
  TOP w0.102: v2(84.38,28.24) 84.39,28.23 U18.T5
  L03_SIG1 w0.121: v1(100.63,24.18) 100.63,23.74 100.82,23.55 101.5,23.55 101.63,23.67 101.63,25.05 101.5,25.17 88.37,25.17 87.5,26.03 85.63,26.03 84.38,27.28 v2(84.38,28.24)
  BOTTOM w0.135: U40.28 104.33,28.34 102.01,26.01 102.01,25.17 101.32,24.49 101.32,22.94 101.19,22.81 100.77,22.81 100.63,22.94 v1(100.63,24.18)
CPSW_RGMII1_RD1: length 33.3
  TOP w0.102: 84.13,25.02 84.13,25.26 83.91,25.49 83.91,26.34 U18.R2
  TOP w0.135: 84.13,25.02 84.13,24.97 84.14,24.97 84.14,24.7 86.16,22.68 86.16,21.16 88.26,19.05 100.46,19.05 v1(102.16,20.75)
  BOTTOM w0.135: U40.26 104.71,27.34 101.73,24.36 101.73,21.18 v1(102.16,20.75)
CPSW_RGMII1_RD2: length 33.1
  TOP w0.102: 85.18,25.26 85.17,25.27 85.17,26.08 U18.U2
  TOP w0.114: 85.18,25.26 85.42,25.02
  TOP w0.135: 85.42,25.02 87.33,23.11 87.33,22.38 88.8,20.9 95.73,20.9 95.86,21.04 95.86,21.63 96,21.77 96.27,21.77 96.4,21.63 96.4,21.04 96.54,20.9 96.81,20.9 96.94,21.04 96.94,21.63 97.08,21.77 97.34,21.77 97.48,21.63 97.48,21.04 97.61,20.9 97.88,20.9 98.02,21.04 98.02,21.63 98.15,21.77 98.42,21.77 98.56,21.63 98.56,21.04 98.69,20.9 98.96,20.9 99.09,21.04 99.09,21.63 99.23,21.77 99.5,21.77 99.63,21.63 99.63,21.04 99.77,20.9 100.15,20.9 101.52,22.28 v1(102.16,22.28)
  BOTTOM w0.135: v1(102.16,22.28) 102.16,23.42 105.08,26.34 U40.24
CPSW_RGMII1_RD3: length 33.1
  TOP w0.102: U18.T1 84.69,25.56 84.69,25.02
  TOP w0.135: v1(103.68,20.75) 103.68,20.3 103.82,20.17 104.36,20.17 104.5,20.3 104.5,21.08 104.32,21.26 101.57,21.26 100.51,20.19 88.27,20.19 86.72,21.74 86.72,22.94 84.69,24.96 84.69,25.02
  BOTTOM w0.135: v1(103.68,20.75) 102.92,21.51 102.92,23.04 105.22,25.34 U40.22
CPSW_RGMII1_RX_CTL: length 33.1
  TOP w0.102: 87.74,26.03 87.38,26.39 87.38,26.56 87.08,26.86 U18.Y3
  TOP w0.135: 87.74,26.03 89.31,24.46 96.8,24.46 97.76,23.49 108.74,23.49 108.99,23.24 108.99,22.52 108.8,22.33 v1(105.21,22.33)
  BOTTOM w0.135: U40.20 107.75,23.68 106.4,22.33 v1(105.21,22.33)
CPSW_RGMII1_RXC: length 33.4
  TOP w0.102: U18.U1 84.89,25.14 85.01,25.02
  TOP w0.135: v1(105.21,20.75) 106.22,20.75 106.4,20.94 106.4,21.39 106.27,21.53 101.34,21.53 100.3,20.5 88.65,20.5 87.05,22.1 87.05,22.99 85.01,25.02
  BOTTOM w0.135: U40.18 108.75,22.77 106.73,20.75 v1(105.21,20.75)
CPSW_RGMII1_TD0: length 28.6
  TOP w0.102: U18.Y14 86.67,32.64 87.12,32.64 87.22,32.54 87.74,32.54
  TOP w0.135: v1(106.17,36.96) 105.22,36 98.18,36 94.72,32.54 87.74,32.54
  BOTTOM w0.135: v1(106.17,36.96) 108.15,36.96 108.75,36.36 108.75,36.1 108.89,35.96 109.49,35.96 109.63,35.83 109.63,35.56 109.49,35.42 108.89,35.42 108.75,35.29 U40.42
CPSW_RGMII1_TD1: length 28.7
  TOP w0.102: 87.74,33.08 86.68,33.08 U18.Y16
  TOP w0.135: v1(104.44,36.83) 103.55,36.83 103.41,36.96 103.41,37.43 103.28,37.57 103.01,37.57 102.87,37.43 102.87,36.89 102.74,36.75 102.47,36.75 102.33,36.89 102.33,37.43 102.2,37.57 101.93,37.57 101.8,37.43 101.8,36.89 101.66,36.75 101.39,36.75 101.26,36.89 101.26,37.43 101.12,37.57 100.85,37.57 100.72,37.43 100.72,36.89 100.58,36.75 98.04,36.75 94.37,33.08 87.74,33.08
  BOTTOM w0.135: U40.40 107.75,34.74 106.39,36.1 105.17,36.1 v1(104.44,36.83)
CPSW_RGMII1_TD2: length 28.8
  TOP w0.102: U18.U13 84.7,31.66 84.7,31.66 v2(84.38,31.34)
  L03_SIG1 w0.121: v2(84.38,31.34) 84.43,31.34 84.79,31.7 86.77,31.7 87.27,32.21 98.02,32.21 99.95,30.28 v1(101.78,30.28)
  BOTTOM w0.135: U40.37 105.61,32.84 103.8,34.65 102.04,34.65 101.78,34.38 v1(101.78,30.28)
CPSW_RGMII1_TD3: length 28.8
  TOP w0.102: U18.AA14 86.99,32.27 87.74,32.27
  TOP w0.135: 87.74,32.27 94.83,32.27 94.87,32.31 94.89,32.31 97.99,35.41 101.73,35.41 102.23,34.9 v1(102.23,34.16)
  BOTTOM w0.135: U40.35 104.94,31.84 104.83,31.95 102.51,31.95 102.16,32.31 102.16,32.78 102.29,32.91 102.56,32.91 102.7,32.78 102.7,32.55 102.83,32.42 103.05,32.42 103.18,32.55 103.18,32.78 103.32,32.91 103.54,32.91 103.67,32.78 103.67,32.55 103.81,32.42 104.01,32.42 104.14,32.55 104.14,33.22 103.91,33.45 102.37,33.45 102.23,33.58 v1(102.23,34.16)
CPSW_RGMII1_TX_CTL: length 28.8
  TOP w0.102: U18.W16 85.89,32.94 v2(85.93,32.9)
  L03_SIG1 w0.121: v2(85.93,32.9) 86.45,32.9 87.78,34.24 94.95,34.24 95.73,35.03 96.03,35.03 96.15,35.15 96.15,35.77 96.27,35.89 96.51,35.89 96.64,35.77 96.64,35.15 96.76,35.03 97,35.03 97.12,35.15 97.12,35.77 97.24,35.89 97.48,35.89 97.6,35.77 97.6,35.15 97.72,35.03 97.96,35.03 98.08,35.15 98.08,35.77 98.2,35.89 98.45,35.89 98.57,35.77 98.57,35.15 98.69,35.03 99.11,35.03 99.9,34.24 99.9,32.52 100.89,31.52 v1(104.32,31.52)
  BOTTOM w0.135: U40.33 105,30.84 104.63,31.2 104.63,31.21 v1(104.32,31.52)
CPSW_RGMII1_TXC: length 28.9
  L03_SIG1 w0.121: v1(91.21,30.56) 91.21,31.2 91.33,31.32 93.5,31.32 93.62,31.2 93.62,30.4 93.74,30.28 93.99,30.28 94.1,30.4 94.1,31.32 94.22,31.44 94.47,31.44 94.59,31.32 94.59,30.4 94.7,30.28 94.95,30.28 95.07,30.4 95.07,31.32 95.19,31.44 95.43,31.44 95.55,31.32 95.55,30.4 95.67,30.28 95.92,30.28 96.03,30.4 96.03,31.32 96.16,31.44 96.4,31.44 96.52,31.32 96.52,30.4 96.64,30.28 96.88,30.28 97,30.4 97,31.32 97.12,31.44 97.72,31.44 100.05,29.11 103.07,29.11 103.88,29.92 v1(104.71,29.92)
  BOTTOM w0.135: v1(104.71,29.92) 104.79,29.84 U40.31 ; R287.2 87.87,31.14 90.63,31.14 v1(91.21,30.56)
DEBOUNCE_MCU_RESETZ: length 85.6
  TOP w0.135: U13.1 58.76,39.66 57.73,40.69 57.73,43.84 58.57,44.68 66.47,44.68 67.02,45.22 67.02,57.74 64.16,60.61 34.62,60.61 34.44,60.78 32.13,60.78 31.14,59.79 26.44,59.79 24.72,61.51 SW2.3 23.53,62.68 22.91,63.3 20.78,63.3 20.16,62.68 SW2.1 18.02,62.68 17.7,62.36 D1.1 18.2,61.38 18.53,61.04 R1.1 C1.1
DEBOUNCE_SOC_RESET_REQZ: length 73.8
  TOP w0.135: C2.1 28.21,60.81 28.2,60.8 D2.1 v1(27.61,61.77) SW3.1 28.77,62.68 29.36,63.27 31.57,63.27 32.17,62.68 SW3.3 34.04,62.68 34.16,62.8 63.26,62.8 67.29,58.77 67.29,45.11 66.55,44.37 61.19,44.37 59.76,42.95 U13.6
  BOTTOM w0.135: Q7.6 26.1,60.62 Q7.8 26.1,59.97 Q7.1 Q7.2 ; Q7.6 Q7.5 ; Q7.6 26.64,61.22 26.82,61.04 R170.1 27.61,61.77 v1(27.61,61.77)
DEBOUNCE_USER_INTN: length 48
  TOP w0.135: U13.3 59.76,37.71 61.03,36.44 61.03,31.7 60.32,30.98 60.32,25.79 63.55,22.56 63.55,19.23 64.82,17.96 64.82,10.74 65.39,10.17 R164.1 65.98,10.17 66.26,9.89 C78.1 66.72,9.87 v1(67.46,9.87) 67.71,10.12 SW5.3 70.14,10.12 71.04,9.22 72.72,9.22 73.62,10.12 SW5.1 74.48,10.89 74.93,11.33 D4.1
  BOTTOM w0.135: Q16.5 Q16.6 64.88,10.35 Q16.8 65.25,10.03 65.57,10.35 Q16.1 Q16.2 67.29,9.7 v1(67.46,9.87)
EEPROM_A1: length 2.3
  TOP w0.135: U17.2 64.04,27.8 64.34,27.51 R121.2
EEPROM_A2: length 2.6
  TOP w0.135: R122.2 65.57,26.8 64.69,27.68 U17.3
EEPROM_WP: length 2.8
  TOP w0.135: U17.7 64.04,35.97 64.39,36.32 64.65,36.32 64.88,36.55 R89.1
EHRPWM0_A: length 75.2
  TOP w0.102: U18.V21 85.39,36.14 85.95,36.7
  TOP w0.135: 85.95,36.7 87.07,37.82 87.07,39.27 88.85,41.05 90.4,41.05 92.51,43.15 92.94,43.15 93.52,43.74 v1(93.52,47.07) 93.38,47.21 R42.1
  L03_SIG1 w0.121: v1(93.52,47.07) 93.52,48.92 91.79,50.65 88.34,50.65 86.53,52.46 80,52.46 79.1,53.36 71.68,53.36 71.3,52.98 69.01,52.98 68.48,53.51 64.59,53.51 63.96,52.88 44.51,52.88 J2.1
EHRPWM0_B: length 80
  TOP w0.102: U18.U21 85.09,36.06 85.09,36.19 85.57,36.67 85.57,36.7
  TOP w0.135: 85.57,36.7 86.66,37.79 86.66,39.34 88.75,41.43 90.4,41.43 v1(92.84,43.87) 92.84,44.84 R59.1
  L03_SIG1 w0.121: v1(92.84,43.87) 92.84,44.5 93.48,45.14 97.11,45.14 97.77,45.81 97.77,46.9 97.16,47.52 96.5,47.52 95.15,48.87 95.15,49.35 93.6,50.9 88.45,50.9 86.64,52.71 80.11,52.71 79.2,53.62 71.45,53.62 71.07,53.24 69.12,53.24 68.74,53.62 68.59,53.77 64.48,53.77 63.91,53.19 46.73,53.19 J2.3
EHRPWM0_TZN_IN0: length 87
  BOTTOM w0.135: J2.13 56.84,57.5 56.84,58.11 57.25,58.52 57.25,59.94 57.81,60.5 70.99,60.5 73.63,57.87 82.75,57.87 84.15,59.26 84.15,60.1 86.29,62.24 121.02,62.24 123.29,59.97 123.29,55.73 126.03,52.98 126.03,50.14 125.71,49.82 U32.17
EHRPWM1_A: length 81.7
  TOP w0.102: U18.T20 84.39,36.07 84.75,36.42 84.75,36.7
  TOP w0.135: 84.75,36.7 84.75,36.85 85.32,37.41 85.32,39.12 89.65,43.45 89.65,43.55 v1(89.97,43.87) 89.97,44.78 R57.1
  L03_SIG1 w0.121: v1(89.97,43.87) 89.97,44.45 90.27,44.75 91.82,44.75 92.13,44.45 92.13,43.64 92.38,43.38 93.09,43.38 93.32,43.61 93.32,44.35 93.86,44.89 97.21,44.89 98.07,45.75 98.07,47.45 94.36,51.16 88.56,51.16 86.15,53.56 79.62,53.56 79.29,53.9 71.32,53.9 70.92,53.49 69.24,53.49 68.71,54.02 64.31,54.02 63.74,53.45 49.02,53.45 J2.5
EHRPWM1_B: length 58.6
  TOP w0.102: v2(84.87,33.86) 84.39,34.33 U18.T18
  TOP w0.135: v1(66.22,54.99) 64.21,54.99 63.58,54.36 50.65,54.36 J2.7
  L03_SIG1 w0.121: v2(84.87,33.86) 84.96,33.95 84.96,35.89 85.27,36.2 85.27,41.27 v1(85.8,41.81)
  BOTTOM w0.135: v1(66.22,54.99) 67.79,54.99 75.59,47.19 76.12,47.19 78.74,44.58 86.16,44.58 86.41,44.82 R217.1 87.71,44.82 87.91,44.62 87.91,42.85 86.87,41.81 v1(85.8,41.81)
EHRPWM2_A: length 57.9
  L03_SIG1 w0.121: v1(101.3,53.59) 96.75,53.59 96.24,54.1 90.4,54.1 90.08,53.78 88.54,53.78 87.93,54.38 84.07,54.38 83.42,55.03 78.72,55.03 78.39,54.7 73.47,54.7 72.97,55.19 69.47,55.19 68.94,55.73 65.22,55.73 63.85,54.36 53.19,54.36 J2.9
  BOTTOM w0.135: v1(101.3,53.59) 101.39,53.5 101.39,51.22 102.06,50.55 U30.3
EHRPWM2_B: length 49.6
  L03_SIG1 w0.121: v1(89.64,54.31) 89.26,54.68 84.18,54.68 83.58,55.28 78.47,55.28 78.14,54.95 73.62,54.95 72.53,56.05 65.18,56.05 63.74,54.61 55.48,54.61 J2.11
  BOTTOM w0.135: v1(89.64,54.31) 91.26,54.31 95.52,50.05 U30.7
EPHY1_XI: length 2.7
  TOP w0.135: U7.20 139.18,52.43 v1(138.79,52.82) 138.79,52.83 138.79,52.84 R13.2
  BOTTOM w0.135: v1(138.79,52.82) 138.79,53.48 R13.2
EQEP1_A: length 24.7
  TOP w0.135: C77.1 157.11,12.67 157.46,12.31 J12.1
  BOTTOM w0.135: C77.1 156.51,11.94 156.82,11.63 157.05,11.63 157.46,11.22 J12.1 157.46,8.82 156.92,8.28 144.55,8.28 143.73,9.11 U46.16
EQEP1_A_LS: length 73.6
  TOP w0.102: 82.18,25.02 82.18,26.07 U18.L2
  TOP w0.135: 82.18,25.02 82.18,20.81 87.07,15.93 v1(90.73,15.93)
  L03_SIG1 w0.121: v1(142.23,10.68) 139.45,13.46 139.45,15.98 138.15,17.27 101.85,17.27 100.51,15.93 v1(90.73,15.93)
  BOTTOM w0.135: U46.1 v1(142.23,10.68)
EQEP1_B: length 19.8
  TOP w0.135: v1(145.62,13.03) 145.62,9.65 146.46,8.81 153.7,8.81 J12.2 154.92,11.2 154.79,11.33 C76.1
  BOTTOM w0.135: J12.2 154.92,11.21 154.79,11.34 C76.1 ; U46.14 145.56,12.97 v1(145.62,13.03)
EQEP1_B_LS: length 70.4
  TOP w0.102: v2(82.39,26.82) 82.35,26.86 U18.L3
  L03_SIG1 w0.121: v1(135.56,18.34) 132.51,18.34 131.2,19.65 112.92,19.65 112.54,19.27 99.31,19.27 98.04,18.01 86.73,18.01 85.97,18.77 84.53,18.77 83.74,19.56 83.74,24.05 82.39,25.4 v2(82.39,26.82)
  BOTTOM w0.135: U46.3 140.06,12.97 135.56,17.48 v1(135.56,18.34)
EQEP1_I: length 14.4
  TOP w0.135: J12.3 152.38,11.2 152.98,11.8 C75.1
  BOTTOM w0.135: U46.13 150.99,13.47 151.8,12.67 C75.1 152.98,11.81 152.38,11.21 J12.3
EQEP1_I_LS: length 66.2
  TOP w0.102: U18.R5 83.89,27.44 v2(83.94,27.38)
  L03_SIG1 w0.121: v1(137.44,20.6) 133.12,20.6 132.29,21.43 114.69,21.43 112.85,23.27 98.7,23.27 97.41,24.56 86.76,24.56 v2(83.94,27.38)
  BOTTOM w0.135: U46.4 140,13.47 137.44,16.03 v1(137.44,20.6)
EQEP2_A: length 20.9
  TOP w0.135: J21.1 157.46,17.52 156.51,18.47 C73.1
  BOTTOM w0.135: U46.12 151.41,13.97 152.27,14.83 157.08,14.83 157.46,15.21 J21.1 157.46,18.69 157.13,19.02 C73.1
EQEP2_A_LS: length 121.5
  TOP w0.102: 76.05,32.2 76.11,32.2 76.22,32.08 77.11,32.08 U18.B14
  TOP w0.135: 76.05,32.2 76.05,32.2 71.32,32.2 70.9,31.78 68.17,31.78 66.96,32.99 63.37,32.99 60.86,30.48 60.86,26.06 64.82,22.1 64.82,18.9 65.49,18.23 65.49,14.09 67.06,12.52 v1(68.3,12.52)
  L03_SIG1 w0.121: v1(138.35,16.18) 138.67,15.87 138.67,12.73 137.31,11.38 100.13,11.38 98.84,12.67 89.47,12.67 86.92,15.21 86.9,15.21 86.86,15.25 71.03,15.25 v1(68.3,12.52)
  BOTTOM w0.135: v1(138.35,16.18) 138.35,15.73 140.11,13.97 U46.5
EQEP2_B: length 16.4
  TOP w0.135: C72.1 154.79,17.68 154.92,17.55 J21.2
  BOTTOM w0.135: C72.1 154.79,16.51 J21.2 153.67,15.14 152.02,15.14 151.35,14.47 U46.11
EQEP2_B_LS: length 94.8
  L03_SIG1 w0.121: v1(140.26,16.94) 138.35,18.85 132.44,18.85 131.37,19.91 112.7,19.91 112.35,19.56 100.07,19.56 97.64,22 v1(93.42,22)
  BOTTOM w0.135: v1(93.42,22) 91.5,20.08 74.87,20.08 71.95,22.99 68.32,22.99 67.15,24.16 67.15,31.85 68.17,32.87 70.31,32.87 71.17,33.73 R244.2 ; U46.6 140.37,14.47 139.75,15.09 139.75,16.43 v1(140.26,16.94)
EQEP2_I: length 14
  TOP w0.135: C71.1 152.98,18.15 152.38,17.55 J21.3
  BOTTOM w0.135: U46.10 150.97,14.97 J21.3 152.38,17.56 152.98,18.16 C71.1
EQEP2_I_LS: length 20.8
  TOP w0.135: U22.3 v1(154.58,23.77)
  BOTTOM w0.135: U46.7 140.55,14.97 140.18,15.34 140.18,16.15 141.68,17.65 147.37,17.65 153.49,23.77 v1(154.58,23.77)
FB_1V1: length 3.1
  BOTTOM w0.203: U39.8 125.73,30.79
  BOTTOM w0.381: R248.2 126.32,30.79 125.73,30.79
  BOTTOM w0.508: R248.2 R247.1
FB_2V5: length 3.1
  BOTTOM w0.203: U33.8 125.73,41.51
  BOTTOM w0.381: 125.73,41.51 126.32,41.51 R233.2
  BOTTOM w0.508: R233.2 R232.1
FSI/BP_MUX_SEL: length 33.7
  TOP w0.102: 87.74,35.18 87.74,35.16 87.16,34.58 86.67,34.58 U18.Y19
  TOP w0.135: 87.74,35.18 89.84,37.29 92.79,37.29 94.08,38.58 v1(96.09,38.58)
  BOTTOM w0.135: U30.1 104.44,51.55 104.84,51.14 R190.2 106.42,51.14 106.93,50.62 106.93,47.65 105.71,46.43 105.71,45.47 98.83,38.58 v1(96.09,38.58)
FSI_RX0_CLK: length 27.4
  BOTTOM w0.135: U30.2 102.23,51.05 102.08,51.19 102.08,51.77 102.28,51.96 102.28,57.01 98.39,60.89 88.73,60.89 87.76,59.92 87.76,57.93 J16.1
FSI_RX0_D0: length 11.2
  BOTTOM w0.135: U30.8 97.83,50.55 97.72,50.44 95.5,50.44 91.55,54.4 J16.5
FSI_RX0_D1: length 46.3
  TOP w0.135: v1(122.63,49.12) 122.05,49.71 122.05,52.76 120.62,54.18 109.78,54.18 108.24,52.64 102.35,52.64 v1(101.85,52.14)
  BOTTOM w0.135: J16.7 93.26,57.47 93.26,58.23 92.86,58.62 92.86,59.92 93.57,60.62 97.24,60.62 101.85,56.01 v1(101.85,52.14) ; v1(122.63,49.12) 122.68,49.17 U32.18
FSI_RX0CLK_PWM2A: length 27
  TOP w0.135: v1(122.94,47.9) 120.8,50.03 120.8,52.6 119.74,53.67 109.8,53.67 108.5,52.37 106.14,52.37 v1(104.39,50.62)
  BOTTOM w0.135: U32.20 122.96,47.87 v1(122.94,47.9) ; v1(104.39,50.62) 104.39,50.23 104.21,50.05 U30.4
FSI_RX0D0_PWM2B: length 50.1
  L03_SIG1 w0.121: v1(92.53,42.57) 93.04,42.57 93.83,43.36 93.83,44.1 94.02,44.29 105.39,44.29 107.13,42.55 110.52,42.55 v1(112.19,44.22)
  BOTTOM w0.135: v1(112.19,44.22) 112.95,43.46 118.87,43.46 120.83,45.42 120.83,46.63 122.71,48.52 U32.19 ; v1(92.53,42.57) 92.33,43.06 92.33,44.5 93.07,45.24 93.07,48.29 94.33,49.55 U30.6
FSI_TX0_CLK: length 25.6
  TOP w0.102: U18.P21 83.59,36.06 83.59,36.22 83.87,36.5 83.87,36.7
  TOP w0.135: J16.2 87.71,57.94 87.71,53.72 85.84,51.86 85.84,44.77 85.29,44.22 85.29,41.15 83.87,39.73 83.87,36.7
FSI_TX0_D0: length 41
  TOP w0.102: 87.74,34.77 87.74,34.75 87.48,34.49 87.48,34.49 87.35,34.36 U18.Y18
  TOP w0.135: v1(98.78,44.98) 98.93,44.83 98.93,41.93 97.69,40.69 97.69,39.37 97.45,39.13 R586.1 96.98,38.51 96.52,38.05 93.93,38.05 92.89,37.01 89.98,37.01 87.74,34.77
  BOTTOM w0.135: v1(98.78,44.98) 98.35,45.41 98.35,47.73 100,49.38 100,51.63 99.05,52.58 94.81,52.58 92.91,54.47 92.91,57.81 J16.6
FSI_TX0_D1: length 38.9
  TOP w0.102: 87.52,35.48 U18.AA19
  TOP w0.114: 87.65,35.62 87.52,35.48
  TOP w0.135: 87.65,35.62 89.6,37.57 92.62,37.57 94.56,39.51 R587.1 95.86,39.51 96.29,39.94 96.29,42.95 96.77,43.43 97.69,43.43 98.25,43.99 98.25,45.77 v1(98.78,46.3)
  BOTTOM w0.135: J16.8 95.26,60.35 97.11,60.35 98.81,58.66 98.81,53.26 100.27,51.8 100.27,49.16 98.78,47.68 v1(98.78,46.3)
GPIO0_50: length 59.2
  TOP w0.102: U18.U14 84.7,32.16 84.69,32.16 v2(84.38,31.85)
  L03_SIG1 w0.121: v2(84.38,31.85) 84.46,31.93 86.59,31.93 87.35,32.69 97.94,32.69 99.91,30.72 105.42,30.72 105.97,31.26 105.97,32.31 108.81,35.15 108.92,35.15 108.92,35.16 115.04,35.16 115.25,35.37 v1(115.7,35.37)
  BOTTOM w0.135: v1(115.7,35.37) 115.7,34.92 115.72,34.89 115.72,20.42 118.21,17.93 118.21,14.73 J5.11
GPIO1_0: length 86
  TOP w0.102: v2(80.41,26.82) 80.48,26.86 U18.J3
  L03_SIG1 w0.121: v1(80.65,18.43) 79.7,18.43 79.35,18.78 79.35,20.19 79.91,20.75 79.91,22.61 79.64,22.88 79.64,26.05 v2(80.41,26.82)
  BOTTOM w0.135: J2.15 58.53,55.35 55.22,52.04 55.22,42.21 49.76,36.75 49.02,36.75 46.54,34.27 46.54,24.25 51.02,19.77 62.78,19.77 63.42,19.13 63.64,18.91 64.8,18.91 66.59,17.12 73.28,17.12 74.29,18.13 80.36,18.13 v1(80.65,18.43)
GPIO1_1: length 83.1
  TOP w0.102: v2(80.41,27.38) 80.46,27.36 U18.J4
  L03_SIG1 w0.121: v2(80.41,27.38) 80.78,27.02 80.78,23.13 80.31,22.67 80.31,19.36 v1(79.89,18.93)
  BOTTOM w0.135: v1(79.89,18.93) 78.24,18.93 77.98,18.67 73.97,18.67 72.96,17.67 66.8,17.67 65.02,19.45 63.86,19.45 62.97,20.34 51.21,20.34 47.67,23.88 47.67,32.17 48.41,32.92 48.42,32.92 48.67,33.17 48.67,33.18 53.02,37.53 53.02,38.31 57.08,42.38 57.08,50.81 61.07,54.79 J2.17
GPIO1_2: length 77.3
  TOP w0.102: U18.G1 79.89,25.57 79.71,25.38 79.71,25.05
  TOP w0.135: v1(77.67,19.38) 78.56,20.27 78.56,23.4 79.71,24.55 79.71,25.05
  BOTTOM w0.135: J2.19 63.61,55.35 59.88,51.63 59.88,42.03 49.4,31.55 49.4,29.11 48.48,28.18 48.48,24.22 50.44,22.25 70.66,22.25 72.69,20.22 73.77,20.22 74.61,19.38 v1(77.67,19.38)
GPIO1_3: length 92.9
  TOP w0.102: U18.H1 80.39,25.55 80.53,25.42 80.53,25.1
  TOP w0.135: v1(80.37,16.56) 78.83,18.1 78.83,23 79.63,23.8 80.19,23.8 80.53,24.14 80.53,25.1
  BOTTOM w0.135: J2.4 42.04,57.93 42.04,54.84 48.06,48.82 48.06,41.43 46.43,39.8 46.43,38.02 44.06,35.65 44.06,22.95 49.71,17.3 64.08,17.3 67.29,14.09 67.63,14.09 75.95,14.09 78.01,16.15 79.96,16.15 v1(80.37,16.56)
GPIO1_4: length 90.2
  TOP w0.102: U18.K2 81.39,26.26 81.11,25.98 81.11,25.75 81.34,25.52 81.34,25.02
  TOP w0.135: v1(82.42,18.05) 82.42,19.23 81.34,20.31 81.34,25.02
  BOTTOM w0.135: v1(82.42,18.05) 81.42,17.04 78.29,17.04 77.37,16.12 76.95,16.12 76.42,16.64 75.27,16.64 73.26,14.63 67.51,14.63 64.31,17.84 51.28,17.84 44.6,24.52 44.6,34.16 47.64,37.2 47.64,40.18 48.59,41.13 48.59,50.44 47.09,51.94 47.09,57.91 J2.8
GPIO1_5: length 84.9
  TOP w0.102: 79.17,25.02 79.17,25.45 79.38,25.66 79.38,26.34 U18.F2
  TOP w0.135: v1(77.39,17.7) 76.73,18.36 76.73,22.71 76.97,22.94 77.22,22.94 79.17,24.89 79.17,25.02
  BOTTOM w0.135: J2.16 57.25,57.91 57.25,55.09 52.58,50.42 52.58,40.87 46.18,34.47 46.18,24.18 51.72,18.64 64.69,18.64 66.47,16.86 73.55,16.86 74.4,17.7 v1(77.39,17.7)
GPIO1_6: length 55.6
  TOP w0.102: 80.8,25.02 80.8,25.49 80.71,25.58 80.71,26.05 U18.H2
  TOP w0.135: 80.8,25.02 80.8,23.79 80.53,23.52 79.93,23.52 79.63,23.22 79.63,22.93 79.91,22.66 79.91,21.97 79.63,21.69 79.63,19.28 79.46,19.11 79.46,18.76 79.63,18.59 79.63,18.54 81.56,16.61 82.83,16.61 86.38,13.07 98.69,13.07 100.63,11.13 119.69,11.13 J5.15
GPIO1_8: length 107.1
  TOP w0.102: U18.H5 80.35,27.86 79.87,27.38 v2(79.85,27.38)
  L03_SIG1 w0.121: v1(130.73,18.08) 130.31,18.51 99.94,18.51 98.65,17.22 81.71,17.22 81.18,17.75 79.66,17.75 78.61,18.8 78.61,22.91 78.77,23.06 78.77,26.3 v2(79.85,27.38)
  BOTTOM w0.135: J6.20 128.52,59.18 131.19,56.52 131.19,18.54 v1(130.73,18.08)
GPIO1_12: length 52.6
  TOP w0.102: U18.K1 81.61,25.65 81.61,25.14
  TOP w0.135: 81.61,25.14 81.61,20.63 86.54,15.7 v1(86.54,13.89)
  BOTTOM w0.135: v1(86.54,13.89) 85.11,15.32 78.49,15.32 76.32,13.16 67.56,13.16 66.09,11.68 52.69,11.68 J1.9
GPIO1_18: length 37.9
  TOP w0.102: U18.K4 v2(81.39,26.82)
  L03_SIG1 w0.121: v2(81.39,26.82) 81.65,26.56 81.65,19.78 v1(83.39,18.05)
  BOTTOM w0.135: J1.15 59.77,12.22 65.64,12.22 67.18,13.77 76.17,13.77 78.28,15.88 81.22,15.88 v1(83.39,18.05)
GPIO1_19: length 51.3
  TOP w0.102: U18.G2 79.58,26.05 79.58,25.58 79.44,25.43 79.44,25.07
  TOP w0.135: 79.44,25.07 79.44,24.66 77.65,22.87 77.65,21.87 77.14,21.36 77.14,19.02 77.82,18.34 77.82,17.18 v1(77.19,16.55)
  L03_SIG1 w0.121: v1(77.19,16.55) 77.91,15.83 87.1,15.83 89.74,13.18 99.22,13.18 100.46,11.94 112.88,11.94 J5.9
GPIO1_20: length 88
  TOP w0.102: U18.L5 81.44,27.86 v2(81.39,27.9)
  L03_SIG1 w0.121: v2(81.39,27.9) 81.03,27.54 81.03,25.12 81.4,24.76 81.4,19.14 v1(81.41,19.13)
  BOTTOM w0.135: J2.20 62.33,57.91 62.33,55.35 58.53,51.55 58.53,45.48 57.73,44.68 57.73,42.16 54.23,38.66 54.23,37.24 48.82,31.83 48.82,29.29 47.94,28.41 47.94,23.99 51.32,20.61 63.08,20.61 63.91,19.78 65.08,19.78 66.92,17.94 72.83,17.94 73.83,18.94 77.84,18.94 78.35,19.44 81.09,19.44 v1(81.41,19.13)
GPIO1_21: length 52.7
  TOP w0.102: U18.J2 80.91,26.34 80.91,25.66 81.07,25.5 81.07,25.05
  TOP w0.135: 81.07,25.05 81.07,23.44 80.32,22.68 80.32,19.51 86.49,13.34 98.83,13.34 100.56,11.61 117.12,11.61 118.24,12.73 118.24,14.75 J5.14
GPIO1_22: length 47.4
  TOP w0.102: 82.63,25.19 82.39,25.43 U18.M2
  TOP w0.135: 82.63,25.19 82.63,24.31 83.13,23.8 83.13,20.24 85.67,17.7 98.12,17.7 98.48,18.06 105.49,18.06 106.28,17.27 120.76,17.27 J5.16
GPIO1_26: length 59.3
  TOP w0.102: U18.F5 v2(79.39,28.32)
  TOP w0.135: J5.18 122.62,17.95 v1(106.4,17.95)
  L03_SIG1 w0.121: v1(106.4,17.95) 101.44,17.95 100.45,16.96 81.51,16.96 80.98,17.49 79.51,17.49 78.26,18.75 78.26,19.99 77.65,20.6 77.65,23.14 78.46,23.95 78.46,26.33 79.39,27.26 v2(79.39,28.32)
GPIO1_31: length 49.6
  TOP w0.102: 83.58,25.09 83.39,25.27 U18.P1
  TOP w0.135: J5.20 124.67,18.44 87.81,18.44 83.96,22.29 83.96,24.12 83.58,24.5 83.58,25.09
GPIO1_32: length 94.3
  TOP w0.102: 83.85,25.2 83.71,25.33 83.71,26.05 U18.P2
  TOP w0.135: v1(129.72,18.08) 129.09,18.71 88.1,18.71 85.09,21.72 85.09,23.37 83.85,24.61 83.85,25.2
  BOTTOM w0.135: J6.17 126.78,54.43 128.68,54.43 130.33,52.77 130.33,24.06 129.13,22.86 129.13,18.66 v1(129.72,18.08)
GPIO1_33: length 84.1
  TOP w0.102: U18.T4 84.92,27.36 v2(84.93,27.35)
  L03_SIG1 w0.121: v1(129.57,22.12) 114.38,22.12 112.95,23.55 107.72,23.55 106.55,24.71 104.34,24.71 102.74,26.31 101.83,26.31 101.45,26.69 89.06,26.69 88,27.75 85.33,27.75 v2(84.93,27.35)
  BOTTOM w0.135: J6.19 130.6,53.14 130.6,23.15 v1(129.57,22.12)
