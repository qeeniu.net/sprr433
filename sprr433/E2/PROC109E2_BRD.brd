# Allegro board PROC109E2_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPIO1_35: length 84.7
  TOP w0.102: U18.M4 81.93,27.36 v2(81.91,27.38)
  L03_SIG1 w0.121: v2(81.91,27.38) 81.91,20.19 84.38,17.73 98.27,17.73 99.56,19.02 113.38,19.02 v1(113.59,19.23)
  BOTTOM w0.135: v1(113.59,19.23) 112.9,19.91 112.9,22.73 114.01,23.84 114.01,37.81 110.94,40.87 110.94,52.56 108.05,55.45 108.05,57.92 J6.4
GPIO1_36: length 73
  TOP w0.102: U18.T3 83.98,26.86 v2(83.94,26.82)
  L03_SIG1 w0.121: v1(113.56,21.62) 99.99,21.62 97.43,24.18 85.14,24.18 83.94,25.38 v2(83.94,26.82)
  BOTTOM w0.135: J6.8 110.59,57.91 110.59,55.02 111.49,54.12 111.49,41.03 114.27,38.25 114.27,22.33 v1(113.56,21.62)
GPIO1_40: length 117.7
  TOP w0.102: U18.E4 78.36,27.89 v2(78.36,27.9)
  L03_SIG1 w0.121: v2(78.36,27.9) 77.76,27.9 74.3,24.44 73.47,24.44 71.7,26.22 69.52,26.22 66.22,29.53 66.22,30.41 63.64,32.99 56.07,32.99 54.61,34.44 v1(54.61,35.43)
  BOTTOM w0.135: v1(54.61,35.43) 60.49,41.31 60.49,45.88 62.84,48.23 62.84,53.95 66.44,57.55 82.82,57.55 84.42,59.15 84.42,59.99 86.4,61.97 119.24,61.97 J6.16
GPIO1_41: length 123.3
  TOP w0.102: 77.77,25.02 78.11,25.35 78.11,26.07 U18.D2
  TOP w0.135: v1(130.28,10.08) 100.81,10.08 98.37,12.53 86.15,12.53 82.83,15.85 78.52,15.85 77.87,15.21 76.13,15.21 75.37,15.97 75.37,22.92 76.47,24.02 76.78,24.02 76.78,24.03 77.77,25.02
  BOTTOM w0.135: J6.18 125.84,57.91 128.58,57.91 130.87,55.62 130.87,18.96 130.28,18.36 v1(130.28,10.08)
GPIO1_61: length 2.6
  TOP w0.135: U22.7 158.72,23.27 TP34.1
GPIO1_77: length 98.5
  TOP w0.102: U18.B17 77.11,33.58 76.48,33.58 76.33,33.73 76.05,33.73
  TOP w0.135: 76.05,33.73 73.53,33.73 72.8,34.47 71.98,34.47 70.33,36.12 68.38,36.12 v1(68.35,36.09)
  BOTTOM w0.135: v1(68.35,36.09) 68.35,38.89 69.62,40.15 69.62,40.66 72.14,43.18 72.14,44.7 71.41,45.43 68.16,45.43 63.11,50.48 63.11,53.84 66.55,57.28 82.71,57.28 82.93,57.28 84.69,59.04 84.69,59.88 86.51,61.7 116.35,61.7 118.21,59.84 118.21,57.92 J6.13
GPIO1_78: length 107.7
  TOP w0.102: U18.C16 77.89,32.93 v2(77.86,32.9)
  TOP w0.135: v1(61.89,36.12) 61.89,37.72 62.51,38.34 62.51,43.28 63.33,44.1 66.66,44.1 67.61,45.05 67.61,57.81 69.62,59.82 75.11,59.82 76.91,58.01 81.81,58.01 85.34,61.54 119.39,61.54 120.78,60.15 120.78,57.89 J6.15
  L03_SIG1 w0.121: v2(77.86,32.9) 77.6,32.65 77.15,32.65 76.35,31.85 71.15,31.85 69.75,30.45 67.94,30.45 67.44,30.96 67.44,32.81 66.52,33.73 64.75,33.73 62.37,36.12 v1(61.89,36.12)
GPIO_OSPI0_RESET_N: length 36
  TOP w0.102: U18.M20 82.69,35.66 82.69,36.26 83.06,36.63 83.06,36.7
  TOP w0.135: v1(83.08,53.14) 83.53,53.14 85.29,51.38 85.29,45.01 83.06,42.78 83.06,36.7
  BOTTOM w0.135: 75.2,53.61 75.75,53.61 75.9,53.76 75.9,55.83 76.25,56.18 83.16,56.18 83.79,55.55 83.79,53.85 v1(83.08,53.14) ; 75.2,53.61 R181.1 ; 75.2,53.61 75.2,53.22 75.74,52.69 U31.1
GPIO_RGMII1_PHY_RSTN: length 78.8
  TOP w0.102: U18.W11 85.89,30.44 v2(85.93,30.4)
  TOP w0.135: v1(119.3,35.61) 119.76,35.15 119.76,24.76 124.46,20.07 130.15,20.07 v1(131.67,18.54)
  L03_SIG1 w0.121: v2(85.93,30.4) 87.38,30.4 87.75,30.03 96.11,30.03 97.28,28.85 102.97,28.85 103.6,28.22 104.37,28.22 106.76,30.61 106.76,31.42 109.98,34.65 118.34,34.65 v1(119.3,35.61)
  BOTTOM w0.135: 142.58,18.86 R275.1 ; 142.58,18.86 142.58,18.45 142.44,18.31 U43.1 ; 142.58,18.86 141.92,18.86 140.79,19.99 138.66,19.99 137.62,21.03 134.16,21.03 v1(131.67,18.54)
GPIO_RGMII2_PHY_RSTN: length 62.6
  TOP w0.102: 87.74,32.81 87.51,32.81 87.46,32.86 U18.Y15
  TOP w0.135: 87.74,32.81 94.48,32.81 94.49,32.82 94.54,32.82 97.99,36.27 104.67,36.27 106.76,38.35 114.2,38.35 115.19,37.36 v1(124.54,37.36)
  L03_SIG1 w0.121: v1(124.54,37.36) 124.54,38.4 125.15,39.01 137.92,39.01 138.19,39.28 138.87,39.28 139.35,38.8 140.66,38.8 v1(140.97,39.12)
  BOTTOM w0.135: U34.1 140.92,37.87 141.17,37.62 141.73,37.62 142.03,37.91 ; 142.03,37.91 141.29,38.66 141.29,38.8 v1(140.97,39.12) ; 142.03,37.91 R236.1
LED1: length 51.5
  TOP w0.135: LD15.1 v1(183.65,10.99)
  L03_SIG1 w0.121: v1(159.44,40.01) 158.37,38.94 158.37,23.29 159.73,21.92 159.73,20.52 165.12,15.14 169.22,15.14 174.3,10.05 182.72,10.05 v1(183.65,10.99)
  BOTTOM w0.135: v1(159.44,40.01) U35.3
LED2: length 48
  TOP w0.135: LD14.1 v1(182.13,10.99)
  L03_SIG1 w0.121: v1(159.44,38.73) 158.62,37.92 158.62,23.39 160.02,22 160.02,20.6 165.23,15.39 169.37,15.39 174.45,10.31 181.45,10.31 v1(182.13,10.99)
  BOTTOM w0.135: U35.4 v1(159.44,38.73)
LED3: length 44.6
  TOP w0.135: LD13.1 v1(180.63,10.99)
  L03_SIG1 w0.121: v1(180.63,10.99) 180.21,10.56 174.65,10.56 169.57,15.65 165.33,15.65 160.32,20.66 160.32,24.79 158.88,26.24 158.88,36.91 v1(159.44,37.47)
  BOTTOM w0.135: U35.5 v1(159.44,37.47)
LED4: length 40.8
  TOP w0.135: LD12.1 v1(179.13,10.99)
  L03_SIG1 w0.121: v1(179.13,10.99) 174.66,10.99 169.74,15.91 165.43,15.91 160.59,20.75 160.59,35.04 v1(159.44,36.2)
  BOTTOM w0.135: v1(159.44,36.2) U35.6
LED_DRV_A0: length 2.6
  BOTTOM w0.135: U35.9 151.03,33.66 150.93,33.55 R245.2
LED_DRV_A1: length 2.6
  BOTTOM w0.135: R241.2 150.77,35.08 150.93,34.93 U35.10
LED_DRV_A2: length 2.9
  BOTTOM w0.135: R243.2 159.66,34.7 159.44,34.93 U35.7
LMK_1G: length 1.9
  TOP w0.135: U6.2 R32.1
LMK_CLK_IN: length 2.6
  TOP w0.135: U6.1 117.21,49.49 116.93,49.77 R26.2
LMK_CLK_IN_R: length 1.8
  TOP w0.135: U3.3 R26.1
MAIN_UART0_RXD: length 63.3
  TOP w0.102: 76.05,29.94 76.16,29.94 76.23,30 76.25,30 76.61,30.36 U18.B10
  TOP w0.135: v1(62.65,29.05) 62.65,29.69 63.53,30.56 65.58,30.56 67.26,28.88 68.66,28.88 69.75,29.98 71.62,29.98 71.83,29.77 73.21,29.77 73.38,29.94 76.05,29.94
  L03_SIG1 w0.127: v1(32.05,13.08) 32.05,12.47 32.51,12.01 34.39,12.01 40.89,18.52 60.6,18.52 63.22,21.13 63.22,28.49 v1(62.65,29.05)
  BOTTOM w0.135: U45.6 32.98,13.48 32.59,13.08 v1(32.05,13.08)
MAIN_UART0_TXD: length 61.5
  TOP w0.102: 76.05,30.21 76.16,30.21 76.32,30.36 76.32,30.42 76.46,30.56 77.1,30.56 U18.B11
  TOP w0.135: 76.05,30.21 73.26,30.21 73.14,30.08 71.9,30.08 71.73,30.25 69.62,30.25 69.16,29.79 66.8,29.79 65.56,31.04 63.45,31.04 62.2,29.79 62.2,28.45 v1(62.57,28.09)
  L03_SIG1 w0.121: 60.55,19.91 40.97,19.91 35,13.94 34.11,13.94 v1(33.15,12.98)
  L03_SIG1 w0.127: v1(62.57,28.09) 61.87,27.4 61.87,21.23 60.55,19.91
  BOTTOM w0.135: v1(33.15,12.98) 33.15,12.56 R592.1 33.9,12.7 33.9,13.18 34.28,13.56 U45.4
MAIN_UART1_CTS#: length 69.8
  TOP w0.102: U18.C11 77.89,31.28 v2(77.86,31.32)
  TOP w0.135: v1(93.29,36.75) 94.01,37.47 96.77,37.47 98.02,38.71 98.02,40.39 98.65,41.02 U12.11
  L03_SIG1 w0.102: 77.06,30.73 77.28,30.73 v2(77.86,31.32)
  L03_SIG1 w0.127: v1(68.1,29.34) 68.61,28.82 75.15,28.82 77.06,30.73
  BOTTOM w0.135: v1(68.1,29.34) 67.78,29.02 67.78,25.36 68.32,24.81 68.32,24.02 68.82,23.53 72.33,23.53 75.25,20.61 90.35,20.61 94.03,24.29 94.03,33.78 93.29,34.52 v1(93.29,36.75)
MAIN_UART1_RTS#: length 108
  TOP w0.114: U18.A11 76.44,30.86 76.32,30.74
  TOP w0.135: v1(97.46,10.65) 96.41,10.65 95.61,11.45 85.71,11.45 82.38,14.78 78.96,14.78 78.01,13.83 67.33,13.83 66.57,14.58 66.57,18.21 66.78,18.42 66.78,21.99 66,22.78 66,23.46 65.46,24 65,24 63.22,25.78 63.22,26.7 61.94,27.98 61.94,29.91 63.34,31.31 65.85,31.31 67.09,30.06 69.03,30.06 69.48,30.52 71.9,30.52 72.07,30.35 73.02,30.35 73.15,30.48 76.06,30.48 76.32,30.74 ; v1(108.9,41.68) 108.89,41.67 U12.5
  BOTTOM w0.135: v1(108.9,41.68) 105.08,41.68 97.66,34.26 97.66,14.86 97.67,14.86 97.67,14.6 98.6,13.67 98.6,11.16 98.1,10.65 v1(97.46,10.65)
MAIN_UART1_RXD: length 105.8
  TOP w0.102: U18.B12 77.11,31.64 76.46,31.64 76.05,31.23
  TOP w0.135: 76.05,31.23 75.83,31.01 74.04,31.01 73.39,31.66 71.59,31.66 71.04,31.11 69.32,31.11 69.09,30.89 68.81,30.6 67.65,30.6 66.4,31.85 62.99,31.85 61.4,30.26 61.4,27.52 61.99,26.93 61.99,25.77 66.24,21.51 66.24,18.69 66.03,18.48 66.03,14.31 67.07,13.27 78.22,13.27 79.19,14.24 82.16,14.24 85.74,10.65 v1(95.38,10.65) ; U12.8 v1(100.44,42.97)
  BOTTOM w0.135: v1(100.44,42.97) 100.44,42.43 97.7,39.69 96.15,39.69 95,38.53 95,37.82 96.39,36.42 96.39,16.61 95.38,15.6 v1(95.38,10.65)
MAIN_UART1_TXD: length 108.7
  TOP w0.102: 76.05,30.85 76.27,31.07 76.6,31.07 U18.A12
  TOP w0.135: v1(99.11,10.67) 98.67,10.22 96.46,10.22 95.5,11.18 85.6,11.18 82.27,14.51 79.07,14.51 78.1,13.54 67.18,13.54 66.3,14.42 66.3,18.32 66.51,18.53 66.51,21.63 62.26,25.88 62.26,27.15 61.67,27.74 61.67,30.14 63.1,31.58 66.06,31.58 67.3,30.33 68.92,30.33 69.37,30.78 72.06,30.78 72.23,30.62 72.91,30.62 73.04,30.75 75.95,30.75 76.05,30.85 ; v1(108.9,39.73) 108.84,39.73 108.83,39.72 U12.2
  BOTTOM w0.135: v1(108.9,39.73) 103.76,39.73 97.93,33.9 97.93,14.97 99.11,13.79 v1(99.11,10.67)
MAIN_UART2_RXD: length 135.2
  L03_SIG1 w0.121: v1(129.29,9.6) 128.71,9.02 90.77,9.02 85.56,14.23 73.64,14.23 68.85,9.44 66.22,9.44 65.15,10.52 48.77,10.52 J1.5
  BOTTOM w0.135: U32.21 123.5,47.22 122.91,46.63 122.91,44.7 123.42,44.2 128.75,44.2 130.05,42.9 130.05,24.33 128.83,23.11 128.83,10.06 v1(129.29,9.6)
MAIN_UART2_TXD: length 106
  TOP w0.102: U18.R20 84.19,35.66 84.19,36.2 84.48,36.49 84.48,36.7
  TOP w0.135: 84.48,36.7 84.48,37.01 85.05,37.58 85.05,39.23 88.52,42.7 v1(88.52,43.87) 88.52,44.84 R56.1
  L03_SIG1 w0.121: v1(88.52,43.87) 88.52,44.83 87.95,45.4 85.74,45.4 84.1,47.04 84.1,47.98 82.39,49.7 72.85,49.7 72.21,50.34 68.95,50.34 64.72,46.11 55.8,46.11 55.28,46.63 43.38,46.63 43.15,46.86 v1(38.3,46.86)
  BOTTOM w0.135: J1.7 47.09,14.74 47.09,19.46 43.71,22.84 43.71,38.81 42.06,40.46 40.49,40.46 38.86,42.09 38.86,46.3 v1(38.3,46.86)
MAIN_UART4_RXD: length 36.8
  TOP w0.102: U18.L1 81.89,25.02
  TOP w0.135: J5.5 107.98,12.12 100.46,12.12 98.96,13.61 88.87,13.61 86.81,15.68 86.81,15.81 81.89,20.72 81.89,25.02
MAIN_UART4_TXD: length 49.4
  TOP w0.102: 78.9,25.02 78.9,25.47 79.17,25.75 79.17,26.08 U18.E2
  TOP w0.135: 78.9,25.02 78.9,25 77.11,23.21 76.8,23.21 76.47,22.87 76.47,16.57 77.04,16 77.86,16 v1(78.45,16.59)
  L03_SIG1 w0.127: J5.7 110.65,12.24 100.56,12.24 99.36,13.44 89.97,13.44 87.32,16.08 78.96,16.08 v1(78.45,16.59)
MCAN0_H: length 9.4
  BOTTOM w0.104: J11.1 165,11.63 165.91,11.63 166.12,11.84 166.12,12.71 164.67,14.16 164.67,14.72 164.57,14.82 164.45,14.82 164.35,14.93 R278.1 164.71,15.83 164.71,16.52 164.52,16.71 U44.7
MCAN0_L: length 9.6
  BOTTOM w0.104: U44.6 165.17,16.71 164.98,16.52 164.98,15.76 R277.2 165.27,14.93 165.17,14.82 165.05,14.82 164.95,14.72 164.95,14.27 166.4,12.83 166.4,11.84 166.6,11.63 167.7,11.63 J11.3
MCAN0_RX: length 9.7
  BOTTOM w0.135: U44.4 165.82,20.89 166.6,21.67 166.6,23.37 165.94,24.03 161.34,24.03 160.87,23.56 R263.2
MCAN0_RX_MUX: length 114
  TOP w0.102: U18.A14 76.4,32.36 76.3,32.47 76.07,32.47 76.05,32.49
  TOP w0.135: v1(68.25,32.33) 68.28,32.33 68.56,32.05 70.79,32.05 71.22,32.49 76.05,32.49 ; U22.6 v1(156.37,22.77)
  L03_SIG1 w0.121: v1(92.46,22) 92.88,22.42 97.6,22.42 100.2,19.82 112.1,19.82 112.52,20.24 131.52,20.24 132.64,19.13 138.68,19.13 139.39,18.42 149.82,18.42 153.26,21.87 155.47,21.87 v1(156.37,22.77)
  BOTTOM w0.135: v1(92.46,22) 90.8,20.34 75.01,20.34 72.09,23.26 68.43,23.26 67.42,24.27 67.42,31.51 v1(68.25,32.33)
MCAN0_RX_SYNC3_OUT: length 3.7
  TOP w0.135: U22.8 159.64,23.77 R131.1 159.89,22.79 v1(159.89,22.78)
  BOTTOM w0.135: R131.1 159.89,23.52 v1(159.89,22.78)
MCAN0_STB: length 104.1
  TOP w0.102: U18.E3 78.48,26.86 v2(78.44,26.82)
  L03_SIG1 w0.121: v2(78.44,26.82) 78.03,26.41 78.03,24 76.69,22.67 76.69,19.76 79.21,17.24 80.86,17.24 81.39,16.71 100.76,16.71 101.57,17.53 138.43,17.53 140.16,15.8 140.16,14.26 142.37,12.05 157.08,12.05 v1(158.17,13.13)
  BOTTOM w0.135: U44.8 163.87,16.66 163.77,16.56 R276.2 162.11,14.36 160.88,13.13 v1(158.17,13.13)
MCAN0_T: length 6.1
  L03_SIG1 w0.121: v1(163.37,14.5) v1(166.25,14.5)
  BOTTOM w0.135: C267.1 167.1,14.25 166.51,14.25 v1(166.25,14.5) R277.1 ; R278.2 v1(163.37,14.5)
MCAN0_TX: length 3.7
  BOTTOM w0.135: U44.1 163.87,20.81 163.52,21.16 R259.2
MCAN0_TX_EQEP2_I: length 148.9
  TOP w0.102: 76.05,31.86 U18.B13
  TOP w0.135: U22.4 154.88,23.27 156.08,22.07 v1(158.55,22.07) ; v1(69.67,12.52) 69.22,12.98 66.98,12.98 65.76,14.2 65.76,18.49 65.13,19.13 65.13,22.25 61.72,25.66 61.72,26.82 61.13,27.41 61.13,30.37 62.88,32.12 66.51,32.12 67.76,30.87 68.66,30.87 69.19,31.41 70.93,31.41 71.46,31.93 75.93,31.93 75.94,31.93 75.95,31.93 76.01,31.86 76.05,31.86
  L03_SIG1 w0.121: v1(69.67,12.52) 72.15,15 86.75,15 89.34,12.41 98.59,12.41 99.9,11.1 138.4,11.1 139.25,10.26 145.08,10.26 146.3,11.48 157.28,11.48 158.88,13.08 158.88,21.74 v1(158.55,22.07)
MCAN0_TX_SYNC2_OUT: length 13.4
  TOP w0.135: R140.1 150.96,23.63 v1(151.31,23.98) 151.6,24.27 U22.2
  BOTTOM w0.135: v1(151.31,23.98) 151.62,24.29 155.66,24.29 158.8,21.16 R259.1
MCAN/EQEP_MUX_SEL: length 99.2
  TOP w0.102: U18.F4 79.39,27.39 78.92,27.86 v2(78.92,27.9)
  TOP w0.135: v1(150.22,25.5) 150.55,25.5 150.75,25.3 150.75,24.99 R128.2 U22.1
  L03_SIG1 w0.121: v2(78.92,27.9) 78.56,28.27 78.2,28.27 78.1,28.17 77.67,28.17 74.42,24.92 v1(73.69,24.92) ; v1(90.7,22.78) 92.02,22.78 92.58,23.34 97.54,23.34 100.56,20.33 111.62,20.33 112.14,20.85 131.88,20.85 132.92,19.81 137.85,19.81 139,20.96 139,23.76 139.3,24.05 139.8,24.05 140.89,22.96 148.59,22.96 150.22,24.59 v1(150.22,25.5)
  BOTTOM w0.135: v1(90.7,22.78) 90.7,21.67 89.99,20.95 76.05,20.95 73.69,23.32 v1(73.69,24.92)
MCU_PORZ: length 69.6
  TOP w0.102: 77.42,36.7 77.45,36.7 78.17,35.98 78.17,35.75 77.89,35.47 U18.C20
  TOP w0.135: v1(34.87,56.62) 34.56,56.3 33.11,56.3 32.46,55.65 TP1.1 31.72,57.12 31.56,57.29 U1.4 ; 77.42,36.7 76.28,37.85 76.28,38.38 75.41,39.24 75.11,39.24 74.44,39.91 74.44,41.86 v1(74.12,42.18)
  L03_SIG1 w0.121: v1(74.12,42.18) 74.12,43.43 72.52,45.03 56.47,45.03 55.15,46.35 43.18,46.35 42.95,46.58 39.65,46.58 39.32,46.25 38.23,46.25 37.59,46.89 35.76,46.89 35.18,46.3 34.21,46.3 33.08,47.44 33.08,50.83 35.26,53.01 35.26,56.24 v1(34.87,56.62)
MCU_RESETSTATZ: length 91.9
  TOP w0.102: U18.A6 76.6,28.07 76.27,28.07 76.05,27.85
  TOP w0.135: 76.05,27.85 75.31,27.1 75.31,27.1 74.27,26.06 TP31.1 74.24,25.4 R126.2 72.71,24.88 73.1,24.49 73.1,21.62 71.86,20.37 71.86,19.48 v1(72.31,19.03)
  L03_SIG1 w0.121: v1(76.56,55.38) 75.47,56.46 65.24,56.46 63.87,55.09 v1(62.74,55.09)
  BOTTOM w0.135: R180.1 v1(76.56,55.38) ; v1(72.31,19.03) 66.21,19.03 65.19,20.05 64.03,20.05 63.17,20.9 51.41,20.9 48.21,24.11 48.21,28.29 49.12,29.21 49.12,31.75 54.5,37.12 54.5,38.47 59.61,43.59 59.61,51.97 v1(62.74,55.09)
MCU_RESETZ: length 30.1
  TOP w0.102: 76.05,27.47 76.45,27.86 U18.A5
  TOP w0.135: v1(74.78,25.91) 75.58,26.71 75.58,26.99 76.05,27.47 ; v1(61.93,33.66) 61.44,34.14 61.44,39.52 TP19.1 60.12,39.57 59.26,40.43 U13.7
  L03_SIG1 w0.121: v1(61.93,33.66) 63.42,33.66 66.47,30.61 66.47,29.63 69.63,26.47 72.25,26.47 72.57,26.16 74.53,26.16 v1(74.78,25.91)
MCU_SAFTY_ERRZ: length 5.6
  TOP w0.102: 76.6,35.08 77.11,35.08 U18.B20
  TOP w0.135: 76.6,35.08 76.5,35.08 74.62,36.96 TP22.1
MCU_UART0_CTS#: length 69.6
  TOP w0.102: U18.D4 77.86,26.82 77.85,26.82 v2(77.86,26.82)
  TOP w0.135: U8.11 v1(103.1,47.88)
  L03_SIG1 w0.121: v2(77.86,26.82) 77.6,26.56 77.6,24.05 76.44,22.89 76.44,19.63 79.08,16.98 80.72,16.98 81.33,16.38 87.5,16.38 88.47,15.42 v1(96.44,15.42)
  BOTTOM w0.135: v1(103.1,47.88) 103.1,43.72 100.17,40.79 99.64,40.79 98.15,39.29 96.14,39.29 95.28,38.43 95.28,37.92 96.76,36.44 96.76,15.73 v1(96.44,15.42)
MCU_UART0_RTS#: length 81.2
  TOP w0.102: U18.C2 77.89,25.52 77.89,25.51
  TOP w0.114: 77.89,25.51 77.39,25.02
  TOP w0.135: v1(98.12,11.73) 97.6,12.26 86.04,12.26 82.71,15.59 78.63,15.59 77.98,14.94 75.89,14.94 75.1,15.73 75.1,23.03 76.36,24.29 76.67,24.29 76.68,24.31 77.39,25.02 ; v1(108.9,48.54) 108.89,48.53 U8.5
  BOTTOM w0.135: v1(108.9,48.54) 109.4,48.04 109.4,45.97 108.46,45.03 107.85,45.03 97.37,34.56 97.37,14.94 97.38,12.48 v1(98.12,11.73)
MCU_UART0_RXD: length 89.3
  TOP w0.102: U18.D6 78.39,28.78 v2(78.44,28.82)
  TOP w0.135: v1(99.36,42.98) 99.36,48.79 100.4,49.83 U8.8
  L03_SIG1 w0.121: v2(78.44,28.82) 78.07,28.45 77.29,28.45 75.26,26.41 72.77,26.41 72.46,26.73 69.73,26.73 66.73,29.74 v1(66.73,32.56)
  BOTTOM w0.135: v1(66.73,32.56) 66.88,32.4 66.88,23.95 68.11,22.72 71.68,22.72 74.59,19.81 91.94,19.81 94.54,22.4 94.54,33.76 93.65,34.65 93.65,36.45 93.9,36.7 93.9,37.82 96.1,40.02 97.6,40.02 99.36,41.78 v1(99.36,42.98)
MCU_UART0_TXD: length 77.5
  TOP w0.102: U18.B2 77.69,26.06 77.69,25.67 77.04,25.02 77.01,25.02
  TOP w0.135: v1(108.9,46.58) 108.84,46.58 108.83,46.58 U8.2 ; 77.01,25.02 76.56,24.56 76.25,24.56 74.83,23.15 74.83,15.61 75.78,14.67 78.09,14.67 78.74,15.32 82.6,15.32 85.93,11.99 96.52,11.99 v1(96.77,11.73)
  BOTTOM w0.135: v1(96.77,11.73) 97.1,12.07 97.1,34.79 v1(108.9,46.58)
OBSCLK0: length 107.3
  L03_SIG1 w0.121: v1(135.53,56.82) 133.61,54.89 110.82,54.89 107.34,51.41 89.74,51.41 87.29,53.86 82.52,53.86 81.85,54.52 78.93,54.52 78.57,54.15 71.12,54.15 70.71,53.75 69.36,53.75 68.66,54.46 v1(65.25,54.46)
  BOTTOM w0.135: v1(135.53,56.82) 137.77,56.82 138.79,55.8 R185.1 ; v1(65.25,54.46) 64.87,54.46 63.92,53.5 63.92,50.84 67.82,46.94 71.04,46.94 73.18,44.81 73.18,43.08 70.46,40.36 70.46,37.82 70.33,37.69 70.33,35.94 71.04,35.23 R240.2
OSC0: length 8.6
  BOTTOM w0.135: Y1.3 11.5,38.02 12.47,38.99 14.55,38.99 15.09,38.44 C131.2 15.53,38.43 15.78,38.69 U37.88
OSC0_XO: length 6.7
  TOP w0.102: U18.C21 77.05,36.7 76.73,36.7
  TOP w0.135: R78.2 73.72,39.39 74.47,38.63 74.8,38.63 76.73,36.7
OSC1: length 6.5
  BOTTOM w0.135: U37.89 15.71,39.09 15.53,39.27 C120.2 13.92,39.27 Y1.1
OSC_STB#: length 1.8
  TOP w0.135: U3.1 R49.2
OSPI0_CLK: length 29.4
  TOP w0.135: U2.16 70.71,46.74 70.38,47.07 69.93,47.07 69.47,46.61 69.47,46.01 R54.1 72.95,45.77 73.66,46.48 73.66,48.07 73.97,48.39 74.36,48.39 74.68,48.07 74.68,46.91 75.15,46.44 75.63,46.44 v1(75.95,46.76) ; R63.2 v1(84.3,42.9)
  BOTTOM w0.135: v1(84.3,42.9) 84.3,41.69 84.44,41.55 85.03,41.55 85.17,41.69 85.17,44.17 85.03,44.31 78.4,44.31 v1(75.95,46.76)
OSPI0_CLK_R: length 6.4
  TOP w0.102: U18.P20 83.11,35.64 83.11,36.03 83.6,36.52 83.6,36.7
  TOP w0.135: R63.1 84.3,40.59 83.6,39.89 83.6,36.7
OSPI0_CS0_N: length 35.7
  TOP w0.102: U18.L20 81.61,35.64 81.61,36.22
  TOP w0.135: U2.7 83.14,54.36 v1(83.14,54.35) ; 81.61,36.22 81.63,36.24 81.63,39.29 82.02,39.67 82.02,43.33 78.03,47.32 76.48,47.32 75.77,48.03 75.77,50.52 76.1,50.85 77.09,50.85 77.39,50.55 v1(77.39,48.23)
  BOTTOM w0.135: v1(83.14,54.35) 82.01,54.35 R183.1 81.69,52.76 79.63,50.7 77.72,50.7 76.86,49.83 76.86,48.77 v1(77.39,48.23)
OSPI0_D0: length 35.6
  TOP w0.102: v2(82.44,34.89) 82.41,34.86 U18.L19
  TOP w0.135: U2.15 70.47,48.01 R36.1 70.01,48.8 v1(70.56,49.35)
  L03_SIG1 w0.121: v2(82.44,34.89) 83.02,35.47 83.02,39.33 82.69,39.67 82.69,45.97 80.08,48.57 78.54,48.57 78.23,48.26 78.23,46.69 77.44,45.9 74.02,45.9 73.4,46.52 73.4,46.69 73.75,47.04 73.75,47.21 73.58,47.38 73.41,47.38 73.06,47.03 72.89,47.03 72.72,47.2 72.72,47.37 73.06,47.72 73.06,47.89 72.89,48.06 72.72,48.06 72.37,47.71 72.2,47.71 72.03,47.88 72.03,48.05 72.38,48.4 72.38,48.57 72.21,48.74 72.04,48.74 71.69,48.39 71.52,48.39 v1(70.56,49.35)
OSPI0_D1: length 35.6
  TOP w0.102: 83.33,36.7 83.33,36.62 82.89,36.18 U18.N20
  TOP w0.135: 83.33,36.7 83.33,42.64 85.57,44.88 85.57,52.8 85.44,52.93 84.16,52.93 84.02,53.06 84.02,53.36 84.16,53.49 86.73,53.49 86.87,53.63 86.87,53.92 86.73,54.06 83.88,54.06 83.74,54.19 83.74,54.51 83.88,54.65 86.23,54.65 86.37,54.79 86.37,55.16 86.22,55.31 84.95,55.31 84.63,55.63 R10.1 U2.8
OSPI0_D2: length 35.7
  TOP w0.102: U18.L21 81.89,36.7 81.9,36.7
  TOP w0.135: 81.9,36.7 81.9,39.13 82.38,39.61 82.38,43.35 77.98,47.75 77.98,51.03 76.77,52.24 76.51,52.24 75.69,51.42 75.5,51.42 75.31,51.61 75.31,51.8 76.13,52.62 76.13,52.81 75.94,53 75.75,53 74.93,52.18 74.74,52.18 74.55,52.37 74.55,52.56 75.37,53.38 75.37,53.57 75.18,53.76 74.99,53.76 74.17,52.94 73.98,52.94 73.79,53.13 73.79,53.32 74.61,54.14 74.61,55.9 73.29,57.22 R5.1 72.04,57.09 U2.9
OSPI0_D3: length 35.7
  TOP w0.102: v2(83.37,34.89) 83.33,34.86 U18.N19
  TOP w0.135: U2.1 82.67,46.74 82.8,46.87 82.8,47.98 82.98,48.16 R37.1 83.54,48.16 83.72,47.98 83.72,47.09 v1(83.36,46.74)
  L03_SIG1 w0.121: v2(83.37,34.89) 83.29,34.98 83.29,40.67 83.79,41.17 83.79,41.48 83.67,41.6 83.06,41.6 82.94,41.73 82.94,42.22 83.06,42.34 84.94,42.34 85.17,42.57 85.17,43.3 85.05,43.42 83.74,43.42 83.62,43.54 83.62,43.78 83.74,43.9 85.27,43.9 85.39,44.02 85.39,44.26 85.27,44.38 83.74,44.38 83.62,44.5 83.62,44.91 83.82,45.11 84.39,45.11 84.51,45.23 84.51,45.75 84.39,45.87 83.21,45.87 81.85,47.23 81.85,47.4 82.31,47.87 82.31,48.04 82.02,48.34 81.82,48.34 81.42,47.93 81.15,47.93 80.72,48.36 80.72,48.59 81.2,49.07 81.93,49.07 83.05,47.95 83.05,47.05 v1(83.36,46.74)
OSPI0_DQS: length 45.9
  TOP w0.102: U18.P17 83.45,33.86 v2(83.94,34.33)
  L03_SIG1 w0.121: v1(95.81,41.37) 98.56,41.37 98.73,41.2 98.73,40.33 98.56,40.16 93.94,40.16 93.82,40.28 93.82,41.18 93.7,41.3 93.46,41.3 93.34,41.18 93.34,40.28 93.22,40.16 92.98,40.16 92.85,40.28 92.85,41.18 92.73,41.3 92.49,41.3 92.37,41.18 92.37,40.28 92.25,40.16 92.01,40.16 91.89,40.28 91.89,41.18 91.77,41.3 91.53,41.3 91.41,41.18 91.41,40.28 91.29,40.16 91.04,40.16 90.92,40.28 90.92,41.18 90.8,41.3 90.56,41.3 90.44,41.18 90.44,40.28 90.32,40.16 90.08,40.16 89.96,40.28 89.96,41.18 89.84,41.3 89.22,41.3 88.29,42.23 87.77,42.23 87.53,41.99 87.53,39.24 87.38,39.09 86.64,39.09 86.44,39.29 86.44,42.06 86.18,42.32 85.65,42.32 83.88,40.54 83.88,36.31 84.3,35.89 84.3,34.69 v2(83.94,34.33)
  BOTTOM w0.135: v1(95.81,41.37) 95.38,41.81 95.38,44.45 95.78,44.85 R213.1
OSPI0_DQS_R: length 16.7
  TOP w0.135: v1(84.81,47.35) 84.81,46.33 83.8,45.32 R65.1
  L03_SIG1 w0.121: v1(84.81,47.35) 85.37,47.35 86.63,46.08 89.84,46.08 90.12,46.36 90.75,46.36 91.71,45.4 96.12,45.4 v1(96.55,45.82)
  BOTTOM w0.135: R213.2 96.52,45.83 96.52,45.82 v1(96.55,45.82)
OSPI0_LBCLKO: length 9
  TOP w0.102: U18.M21 82.17,36.09 82.17,36.7
  TOP w0.135: 82.17,36.7 82.17,38.96 82.17,38.96 82.17,39.01 82.65,39.5 82.65,43.78 R65.2
PORZ_OUT: length 225
  TOP w0.102: v2(77.86,34.89) 77.86,34.9 77.86,34.9 v2(77.86,34.89) ; v2(77.86,34.89) U18.D18
  TOP w0.135: v1(72.24,40.85) 72.24,40.18 TP14.1 72.42,39.48 72.61,39.29 R87.2 ; v1(139.95,19.33) 139.27,20.02 133.68,20.02 130.96,22.73 130.96,32.89 135.03,36.96 138.61,36.96 139.7,38.05 v1(139.7,39.37) 138.99,40.08 132.16,40.08 130.71,41.53 130.71,44.02 v1(129.13,45.59) 128.82,45.91 124.88,45.91 123.65,47.14 123.65,50.11 123.09,50.67 123.09,53.41 121.79,54.71 119.28,54.71 118.24,55.75 118.24,59.77 117,61 85.76,61 82.12,57.35 80.09,57.35 78.94,56.21 v1(78.94,52.85)
  L03_SIG1 w0.121: v1(78.94,52.85) 78.11,52.02 76.05,52.02 75.46,52.61 67.86,52.61 67.47,53 64.53,53 64.05,52.53 40.26,52.53 v1(39.17,51.44) ; v1(72.24,40.85) 71.2,40.85 70.11,39.76 70.11,36.39 71.2,35.31 77.45,35.31 v2(77.86,34.89)
  BOTTOM w0.135: U28.2 v1(39.17,51.44) ; U43.2 v1(139.95,19.33) ; R179.1 78.55,54.59 78.94,54.19 v1(78.94,52.85) 78.94,51.77 78.15,50.97 72.6,50.97 67.87,55.7 66.32,55.7 65.79,55.17 65.79,54.31 65.23,53.75 64.85,53.75 64.19,53.09 64.19,50.95 67.92,47.22 71.15,47.22 73.48,44.88 73.48,41.12 73.21,40.85 v1(72.24,40.85) ; v1(129.13,45.59) 129.97,46.43 129.97,50.57 129.77,50.77 U29.2 ; U34.2 139.4,38.62 139.7,38.92 v1(139.7,39.37)
PRG1_CPSW_ETH1_CLK_OUT: length 2.6
  TOP w0.135: U19.40 138.68,23.09 TP33.1
PRG1_CPSW_ETH1_D0M: length 30.7
  TOP w0.102: U19.2 144.08,26.78 144.18,26.68 163.03,26.68 165.69,24.02 169.19,24.02 170.82,22.38 171.07,22.38 J19.10
PRG1_CPSW_ETH1_D0P: length 30.7
  TOP w0.102: U19.1 144.08,26.28 144.18,26.38 162.91,26.38 165.57,23.72 169.06,23.72 170.7,22.08 171.07,22.08 J19.11
PRG1_CPSW_ETH1_D1M: length 52.8
  TOP w0.102: U19.5 144.08,28.28 144.18,28.18 163.83,28.18 v1(164.13,28.49)
  BOTTOM w0.102: J19.5 175.34,23.09 176.18,23.09 176.89,22.38 176.89,16.94 176,16.05 170.02,16.05 167.59,18.48 167.59,25.86 165.4,28.04 163.89,28.04 163.78,28.15 163.78,28.39 163.87,28.49 v1(164.13,28.49)
PRG1_CPSW_ETH1_D1P: length 52.9
  TOP w0.102: v1(164.13,27.58) 163.83,27.88 144.18,27.88 144.08,27.78 U19.4
  BOTTOM w0.102: v1(164.13,27.58) 164.3,27.74 165.28,27.74 167.29,25.73 167.29,18.36 169.9,15.75 176.12,15.75 177.19,16.81 177.19,22.5 176.3,23.39 175.34,23.39 J19.4
PRG1_CPSW_ETH1_D2M: length 34.2
  TOP w0.102: U19.8 144.08,29.78 144.18,29.68 165.54,29.68 169.37,25.86 172.63,25.86 172.98,26.21 172.98,27.12 173.32,27.46 173.62,27.46 J19.2
PRG1_CPSW_ETH1_D2P: length 34.2
  TOP w0.102: J19.3 173.6,27.16 173.44,27.16 173.28,27 173.28,26.09 172.75,25.56 169.24,25.56 165.42,29.38 144.18,29.38 144.08,29.28 U19.7
PRG1_CPSW_ETH1_D3M: length 36.6
  TOP w0.102: v1(163.88,31.49) 163.57,31.18 144.18,31.18 144.08,31.28 U19.11
  BOTTOM w0.102: v1(163.88,31.49) 163.65,31.49 163.53,31.37 163.53,31.14 163.64,31.03 164.91,31.03 170.16,25.77 172.6,25.77 173.06,26.24 173.06,28.07 172.97,28.16 172.8,28.16 J19.9
PRG1_CPSW_ETH1_D3P: length 36.6
  TOP w0.102: U19.10 144.08,30.78 144.18,30.88 163.57,30.88 v1(163.88,30.57)
  BOTTOM w0.102: J19.8 172.8,28.46 173.1,28.46 173.36,28.2 173.36,26.12 172.72,25.48 170.04,25.48 164.79,30.73 164.04,30.73 v1(163.88,30.57)
PRG1_CPSW_ETH1_LED1: length 10.3
  BOTTOM w0.135: J19.13 169.4,33.24 168.43,34.21 Q13.5 Q13.6 164.24,33.56 Q13.8 163.59,33.56 Q13.1 Q13.2
PRG1_CPSW_ETH1_LED2: length 21.9
  L03_SIG1 w0.121: v1(161.47,30.25) 160.88,29.67 160.88,26.77 162.53,25.12 164.34,25.12 166.55,22.91 166.55,22.03 J19.16
  BOTTOM w0.135: Q14.2 Q14.1 ; Q14.1 157,30.24 R252.1 ; Q14.1 159.45,30.24 Q14.8 160.1,30.24 Q14.6 ; v1(161.47,30.25) 161.45,30.24 Q14.6 ; Q14.6 Q14.5
PRG1_CPSW_ETH1_LED3: length 16.5
  L03_SIG1 w0.121: J19.15 169.39,21.72 163.75,27.36 v1(161.47,27.36)
  BOTTOM w0.135: Q15.6 160.1,27.34 Q15.8 159.45,27.34 Q15.1 ; Q15.6 Q15.5 ; Q15.6 161.45,27.34 v1(161.47,27.36) ; Q15.1 Q15.2 ; Q15.1 158.06,27.34 157.69,26.97 R257.1
PRG1_CPSW_ETH1_LED_1000/RX_ER: length 30.2
  TOP w0.135: U19.46 141.68,24.84 142.42,24.1 144.61,24.1 144.76,23.95 R138.1 145,23.16 145.32,23.16 v1(145.56,23.4)
  BOTTOM w0.135: R138.1 v1(145.56,23.4) 145.95,23.01 145.95,21.41 146.46,20.9 148.41,20.9 149.68,22.17 149.68,27.28 154.94,32.54 158.22,32.54 158.8,31.96 Q14.3
PRG1_CPSW_ETH1_LED_ACT: length 29.2
  TOP w0.135: v1(144.02,23.39) 143.81,23.19 143.5,23.19 R137.1 143.25,23.4 142.81,23.84 142.21,23.84 141.18,24.86 U19.45
  BOTTOM w0.135: Q15.3 158.8,29.06 158.45,29.41 152.88,29.41 150.77,27.3 150.77,22.45 148.79,20.47 145.06,20.47 144.02,21.51 v1(144.02,23.39) 144.01,23.4 R137.1
PRG1_CPSW_ETH1_LED_LINK: length 30.4
  TOP w0.135: v1(147.39,23.4) 147.18,23.19 146.8,23.19 R139.1 146.59,23.95 146.15,24.38 142.64,24.38 142.18,24.84 U19.47
  BOTTOM w0.135: R139.1 v1(147.39,23.4) 148.44,24.45 148.44,27.3 154.03,32.89 161.49,32.89 162.1,33.5 162.1,34.53 162.44,34.86 Q13.3
PRG1_CPSW_ETH1_RBIAS: length 1.3
  TOP w0.254: U19.12 R102.1
PRG1_CPSW_ETH2_CLK_OUT: length 2.6
  TOP w0.135: U7.40 138.68,42.14 TP11.1
PRG1_CPSW_ETH2_D0M: length 29.5
  TOP w0.102: J18.10 171.07,44.23 170.79,44.23 169.29,45.73 144.18,45.73 144.08,45.83 U7.2
PRG1_CPSW_ETH2_D0P: length 29.5
  TOP w0.102: J18.11 171.07,43.93 170.67,43.93 169.17,45.43 144.18,45.43 144.08,45.33 U7.1
PRG1_CPSW_ETH2_D1M: length 51.3
  TOP w0.102: v1(163.88,47.54) 163.57,47.23 144.18,47.23 144.08,47.33 U7.5
  BOTTOM w0.102: J18.5 175.33,44.93 175.88,44.93 177.12,43.69 177.12,38.96 175.87,37.71 168.32,37.71 167.39,38.65 167.39,44.98 165.28,47.09 163.63,47.09 163.5,47.22 163.5,47.39 163.65,47.54 v1(163.88,47.54)
PRG1_CPSW_ETH2_D1P: length 51.3
  TOP w0.102: v1(163.88,46.63) 163.57,46.93 144.18,46.93 144.08,46.83 U7.4
  BOTTOM w0.102: J18.4 175.35,45.23 176,45.23 177.42,43.82 177.42,38.84 176,37.41 168.2,37.41 167.09,38.52 167.09,44.86 165.15,46.79 164.05,46.79 v1(163.88,46.63)
PRG1_CPSW_ETH2_D2M: length 33.1
  TOP w0.102: J18.2 173.61,49.3 173.33,49.3 173.05,49.02 173.05,48.1 172.65,47.69 169.07,47.69 168.03,48.73 144.18,48.73 144.08,48.83 U7.8
PRG1_CPSW_ETH2_D2P: length 33.1
  TOP w0.102: J18.3 173.61,49 173.45,49 173.35,48.9 173.35,47.97 172.77,47.4 168.95,47.4 167.91,48.43 144.18,48.43 144.08,48.33 U7.7
PRG1_CPSW_ETH2_D3M: length 35.3
  TOP w0.102: U7.11 144.08,50.33 144.18,50.23 163.57,50.23 v1(163.88,50.54)
  BOTTOM w0.102: J18.9 172.8,50.01 173.03,50.01 173.13,49.91 173.13,48.32 172.62,47.82 167.89,47.82 165.61,50.1 163.6,50.1 163.5,50.2 163.5,50.44 163.6,50.54 v1(163.88,50.54)
PRG1_CPSW_ETH2_D3P: length 35.3
  TOP w0.102: v1(163.88,49.62) 163.57,49.93 144.18,49.93 144.08,49.83 U7.10
  BOTTOM w0.102: v1(163.88,49.62) 164.06,49.81 165.49,49.81 167.77,47.52 172.75,47.52 172.92,47.69 172.92,47.7 173.42,48.2 173.42,50.04 173.15,50.31 172.8,50.31 J18.8
PRG1_CPSW_ETH2_LED1: length 7.8
  BOTTOM w0.135: Q10.5 Q10.6 ; Q10.6 166.75,55.87 Q10.8 166.1,55.87 Q10.1 Q10.2 ; Q10.6 168.7,55.87 169.4,55.16 J18.13
PRG1_CPSW_ETH2_LED2: length 9.9
  L03_SIG1 w0.121: v1(165.68,40.34) 166.38,41.03 J18.16
  BOTTOM w0.135: R220.1 161.35,39.69 Q11.1 ; Q11.1 Q11.2 ; Q11.1 163.59,39.69 Q11.8 164.24,39.69 Q11.6 Q11.5 v1(165.68,40.34)
PRG1_CPSW_ETH2_LED3: length 17.3
  L03_SIG1 w0.121: J18.15 165.06,43.57 164.26,42.77 164.26,40.28 165.68,38.86 v1(165.68,37.44)
  BOTTOM w0.135: Q12.2 Q12.1 ; Q12.1 163.59,36.79 Q12.8 164.24,36.79 Q12.6 Q12.5 v1(165.68,37.44) ; Q12.1 161.35,36.79 R223.1
PRG1_CPSW_ETH2_LED_1000/RX_ER: length 30
  TOP w0.135: U7.46 141.68,43.84 142.42,43.1 143.08,43.1 143.29,42.9 R75.1 143.5,42.24 143.77,42.24 v1(143.99,42.45)
  BOTTOM w0.135: R75.1 v1(143.99,42.45) 144.48,41.96 144.48,40.36 144.93,39.9 145.97,39.9 150.5,44.42 161.19,44.42 162.94,42.68 Q11.3
PRG1_CPSW_ETH2_LED_ACT: length 33.1
  TOP w0.135: v1(142.52,42.44) 142.32,42.24 142,42.24 R74.1 141.79,43.15 141.18,43.75 U7.45
  BOTTOM w0.135: R227.2 142.51,42.45 v1(142.52,42.44) 142.52,40.81 143.86,39.47 146.35,39.47 150.77,43.89 159.69,43.89 160.66,42.93 160.66,39.4 161.12,38.94 162.51,38.94 162.94,38.51 Q12.3
PRG1_CPSW_ETH2_LED_LINK: length 34
  TOP w0.135: U7.47 142.18,43.8 142.57,43.41 144.61,43.41 145.01,43 R76.1 145.22,42.24 145.59,42.24 v1(145.8,42.44)
  BOTTOM w0.135: R225.2 145.79,42.45 v1(145.8,42.44) 147.14,42.44 152.83,48.13 158.67,48.13 162.23,51.69 162.23,55.25 164.15,57.16 Q10.3
PRG1_CPSW_ETH2_RBIAS: length 1.3
  TOP w0.254: U7.12 R22.1
PRG1_CPSW_RGMII1_CLK: length 32.7
  TOP w0.135: U19.20 139.18,33.16 v1(138.96,33.38) ; v1(131.75,48.92) 130.3,50.37 R25.2
  BOTTOM w0.135: v1(138.96,33.38) 137.62,33.38 136.96,34.03 136.96,38.36 137.97,39.37 138.91,39.37 138.92,39.38 138.98,39.38 139.77,40.18 139.77,41.25 141.22,42.7 141.22,44.53 140.34,45.42 138.81,45.42 134.39,49.83 133.25,49.83 132.33,48.92 v1(131.75,48.92)
PRG1_CPSW_RGMII1_CLK_R: length 2.7
  TOP w0.135: U6.8 125.69,49.49 125.96,49.76 125.96,50.09 126.24,50.37 R25.1
PRG1_CPSW_RGMII1_GPIO_1: length 3.6
  TOP w0.135: U19.22 R95.2 137.97,34.54 137.59,34.54 v1(137.39,34.34)
  BOTTOM w0.135: v1(137.39,34.34) 137.4,34.33 R95.2
PRG1_CPSW_RGMII1_RD0: length 33.8
  TOP w0.135: U19.33 135.5,27.78 134.67,26.95 134.67,26.29 134.51,26.12 R123.1 133.78,26.31 133.78,26.64 v1(133.99,26.85)
  L03_SIG1 w0.121: v1(111.87,27.84) 112.37,27.84 114.65,25.56 126.17,25.56 126.29,25.44 126.29,25.11 126.41,24.99 126.65,24.99 126.77,25.11 126.77,25.44 126.89,25.56 127.13,25.56 127.25,25.44 127.25,25.11 127.37,24.99 127.61,24.99 127.74,25.11 127.74,25.44 127.86,25.56 128.1,25.56 128.22,25.44 128.22,25.11 128.34,24.99 128.58,24.99 128.7,25.11 128.7,25.44 128.82,25.56 132.7,25.56 v1(133.99,26.85)
  BOTTOM w0.135: R254.2 133.99,26.07 v1(133.99,26.85) ; U40.11 111.37,28.34 v1(111.87,27.84)
PRG1_CPSW_RGMII1_RD1: length 33.8
  TOP w0.135: U19.34 135.56,27.28 134.95,26.67 134.95,25.12 134.52,24.69 R129.2 133.76,24.9 133.76,25.15 133.99,25.37 v1(133.99,25.39)
  L03_SIG1 w0.121: v1(110.68,27.84) 111.19,27.33 112.34,27.33 115.41,24.27 120.35,24.27 120.47,24.39 120.47,24.67 120.59,24.79 120.83,24.79 120.95,24.67 120.95,24.39 121.07,24.27 121.31,24.27 121.43,24.39 121.43,24.67 121.55,24.79 121.8,24.79 121.92,24.67 121.92,24.39 122.04,24.27 132.86,24.27 v1(133.99,25.39)
  BOTTOM w0.135: R129.2 133.99,24.7 v1(133.99,25.39) ; U40.12 v1(110.68,27.84)
PRG1_CPSW_RGMII1_RD2: length 33.7
  TOP w0.135: 133.24,23.4 133.23,23.39 v1(132.5,23.39) ; 133.24,23.4 R132.1 ; 133.24,23.4 133.82,23.98 134.29,23.98 135.25,24.94 135.25,26.55 135.49,26.78 U19.35
  L03_SIG1 w0.121: v1(132.5,23.39) 125.44,23.39 125.32,23.51 125.32,23.7 125.2,23.83 124.96,23.83 124.84,23.7 124.84,23.51 124.72,23.39 124.48,23.39 124.36,23.51 124.36,23.83 124.24,23.95 124,23.95 123.88,23.83 123.88,23.51 123.75,23.39 123.51,23.39 123.39,23.51 123.39,23.83 123.27,23.95 123.03,23.95 122.91,23.83 122.91,23.51 122.79,23.39 115.82,23.39 112.38,26.84 v1(111.87,26.84)
  BOTTOM w0.135: R132.1 132.51,23.4 v1(132.5,23.39) ; U40.13 111.37,27.34 v1(111.87,26.84)
PRG1_CPSW_RGMII1_RD3: length 33.7
  TOP w0.135: U19.36 135.74,26.28 135.53,26.07 135.53,24.76 134.73,23.95 R133.1 134.94,23.19 135.28,23.19 v1(135.48,23.39)
  L03_SIG1 w0.121: v1(135.48,23.39) 134.92,23.95 134.16,23.95 133.18,22.97 115.71,22.97 112.34,26.34 111.18,26.34 v1(110.68,26.84)
  BOTTOM w0.135: R133.1 134.73,23.39 v1(135.48,23.39) ; U40.14 v1(110.68,26.84)
PRG1_CPSW_RGMII1_RSTN: length 5.5
  TOP w0.135: v1(140.61,24.1) 140.18,24.54 U19.43
  BOTTOM w0.135: v1(140.61,24.1) 140.61,23.52 139,21.91 U43.4
PRG1_CPSW_RGMII1_RX_CTL: length 33.8
  TOP w0.135: v1(136.93,23.39) 136.73,23.19 136.44,23.19 R134.2 136.22,23.95 136.56,24.28 137.37,24.28 137.68,24.6 U19.38
  L03_SIG1 w0.121: v1(111.87,25.84) 112.39,25.84 115.51,22.71 133.51,22.71 133.76,22.96 136.5,22.96 v1(136.93,23.39)
  BOTTOM w0.135: v1(136.93,23.39) 136.92,23.4 R134.2 ; U40.15 111.37,26.34 v1(111.87,25.84)
PRG1_CPSW_RGMII1_RXC: length 30.4
  TOP w0.135: R115.1 132.95,27.56 v1(132.28,27.56)
  L03_SIG1 w0.121: v1(132.28,27.56) 131.55,26.83 115.13,26.83 113.61,28.35 109.88,28.35 109.5,27.97 109.5,25.22 109.86,24.87 110.35,24.87 110.68,25.2 v1(110.68,25.84)
  BOTTOM w0.135: U40.16 v1(110.68,25.84)
PRG1_CPSW_RGMII1_RXC_R: length 2.8
  TOP w0.135: U19.32 135.21,28.28 134.5,27.57 R115.2
PRG1_CPSW_RGMII1_TD0: length 31.3
  TOP w0.135: v1(132.51,32.33) 133.2,32.33 135.25,30.28 U19.28
  L03_SIG1 w0.121: v1(132.51,32.33) 132.51,31.7 132.01,31.2 131.34,31.2 130.41,32.12 128.83,32.12 128.71,32 128.71,31.74 128.59,31.62 128.35,31.62 128.23,31.74 128.23,32 128.11,32.12 127.87,32.12 127.75,32 127.75,31.74 127.63,31.62 127.39,31.62 127.27,31.74 127.27,32 127.15,32.12 126.9,32.12 126.78,32 126.78,31.74 126.66,31.62 126.42,31.62 126.3,31.74 126.3,32 126.18,32.12 112.6,32.12 112.31,32.41 v1(111.87,32.41)
  BOTTOM w0.135: v1(111.87,32.41) 111.44,32.84 U40.2
PRG1_CPSW_RGMII1_TD1: length 31
  TOP w0.135: v1(134.16,32.94) 134.16,31.88 135.26,30.78 U19.27
  L03_SIG1 w0.121: v1(134.16,32.94) 134.6,32.94 134.7,32.85 134.7,32.33 134.54,32.18 133.53,32.18 132.29,30.94 125.75,30.94 125.47,31.22 113.86,31.22 113.26,31.83 111.28,31.83 v1(110.77,32.33)
  BOTTOM w0.135: v1(110.77,32.33) 110.77,32.34 U40.3
PRG1_CPSW_RGMII1_TD2: length 31.2
  TOP w0.135: v1(134.92,31.8) 135.44,31.28 U19.26
  L03_SIG1 w0.121: v1(134.92,31.8) 133.55,31.8 132.08,30.33 128.71,30.33 128.59,30.21 128.59,29.86 128.47,29.74 128.23,29.74 128.11,29.86 128.11,30.29 127.99,30.41 127.75,30.41 127.63,30.29 127.63,29.86 127.51,29.74 127.26,29.74 127.14,29.86 127.14,30.29 127.02,30.41 126.78,30.41 126.66,30.29 126.66,29.86 126.54,29.74 126.3,29.74 126.18,29.86 126.18,30.21 126.06,30.33 120.75,30.33 120.23,30.85 113.7,30.85 113.16,31.39 v1(111.87,31.39)
  BOTTOM w0.135: v1(111.87,31.39) 111.42,31.84 U40.4
PRG1_CPSW_RGMII1_TD3: length 31.2
  TOP w0.135: v1(135.69,32.94) 135.69,31.98 135.88,31.78 U19.25
  L03_SIG1 w0.121: v1(135.69,32.94) 136,32.63 136,31.71 135.33,31.04 133.4,31.04 131.84,29.48 120.59,29.48 120.3,29.76 113.57,29.76 112.37,30.96 111.05,30.96 v1(110.68,31.34)
  BOTTOM w0.135: U40.5 v1(110.68,31.34)
PRG1_CPSW_RGMII1_TX_CTL: length 31.3
  TOP w0.135: v1(137.19,24.73) 137.19,24.79 137.18,24.79 U19.37
  L03_SIG1 w0.121: v1(111.87,30.47) 111.87,29.71 112.85,28.73 114.71,28.73 115.32,28.12 133.8,28.12 v1(137.19,24.73)
  BOTTOM w0.135: U40.6 111.5,30.84 v1(111.87,30.47)
PRG1_CPSW_RGMII1_TXC: length 31.4
  TOP w0.135: v1(131.76,31.62) 133.35,31.62 135.19,29.78 U19.29
  L03_SIG1 w0.121: v1(110.68,30.34) 110.16,30.85 110.16,32.43 110.57,32.84 121.05,32.84 121.54,33.32 130.05,33.32 v1(131.76,31.62)
  BOTTOM w0.135: U40.7 v1(110.68,30.34)
PRG1_CPSW_RGMII2_CLK: length 19.5
  TOP w0.135: R50.2 130.58,46.74 132.18,48.34 132.18,54.66 133.35,55.83 138.28,55.83 138.79,55.32 R13.1
PRG1_CPSW_RGMII2_CLK_R: length 2.7
  TOP w0.135: R50.1 126.29,46.74 126.03,46.99 126.03,47.29 125.79,47.54 U6.5
PRG1_CPSW_RGMII2_GPIO_1: length 3.7
  TOP w0.135: U7.22 138.18,53.05 v1(137.72,53.52) 137.71,53.51 R12.2
  BOTTOM w0.135: R12.2 137.71,53.51 v1(137.72,53.52)
PRG1_CPSW_RGMII2_RD0: length 74.7
  TOP w0.102: 87.62,30.36 U18.AA10
  TOP w0.135: v1(104.55,35.2) 103.61,35.2 103.02,34.62 103.02,33.83 98.96,29.77 89,29.77 88.41,30.36 87.62,30.36 ; v1(133.99,45.9) 133.83,45.75 133.83,45.3 R64.1 134.52,45.16 134.7,45.34 134.7,46.02 135.5,46.83 U7.33
  L03_SIG1 w0.121: v1(104.55,35.2) 101.82,35.2 101.57,35.45 101.57,36.02 101.82,36.27 106.45,36.27 106.66,36.48 113.28,36.48 114.63,37.83 114.63,39.79 120.86,46.02 127.93,46.02 129.76,47.85 130.16,47.85 130.28,47.73 130.28,45.72 130.44,45.56 130.74,45.56 130.87,45.68 130.87,47.88 130.99,48 131.33,48 131.45,47.88 131.45,46.16 131.82,45.8 132.23,45.8 132.72,45.31 133.4,45.31 v1(133.99,45.9)
  BOTTOM w0.135: v1(133.99,45.9) 133.99,45.2 R64.1
PRG1_CPSW_RGMII2_RD1: length 74.7
  TOP w0.102: U18.Y10 86.67,30.08 87.74,30.08
  TOP w0.135: v1(103.53,34.11) 103.53,33.96 99.07,29.49 88.87,29.49 88.28,30.08 87.74,30.08 ; U7.34 135.64,46.33 135,45.69 135,44.23 134.51,43.74 R68.2 133.78,43.93 133.78,44.22 133.99,44.42 v1(133.99,44.44)
  L03_SIG1 w0.121: v1(133.99,44.44) 127.44,44.44 127.1,44.09 126.45,44.09 126.13,44.41 126.13,45.39 126.01,45.51 125.77,45.51 125.65,45.39 125.65,44.41 125.53,44.29 125.29,44.29 125.17,44.41 125.17,45.39 125.05,45.51 124.81,45.51 124.69,45.39 124.69,43.7 124.57,43.58 124.32,43.58 124.2,43.7 124.2,45.39 124.08,45.51 123.84,45.51 123.72,45.39 123.72,44.41 123.6,44.29 122.4,44.29 118.28,40.17 118.28,39.7 117.49,38.91 116.53,38.91 113.56,35.95 107.19,35.95 104.07,32.82 101.26,32.82 101.14,32.94 101.14,33.51 101.26,33.63 103.05,33.63 v1(103.53,34.11)
  BOTTOM w0.135: v1(133.99,44.44) 133.99,43.75 R68.2
PRG1_CPSW_RGMII2_RD2: length 75
  TOP w0.102: U18.Y11 86.67,31.14 87.33,31.14
  TOP w0.135: U7.35 135.6,45.83 135.28,45.52 135.28,44.02 134.29,43.03 133.82,43.03 133.24,42.45 R71.1 132.63,42.45 v1(132.49,42.6) ; 87.33,31.14 87.37,31.09 95.86,31.09 97.93,33.16 99.25,33.16 99.57,32.84 99.57,32.16 99.7,32.03 100.1,32.03 v1(100.63,32.56)
  L03_SIG1 w0.121: v1(100.63,32.56) 101.42,32.56 101.54,32.44 101.54,31.95 101.66,31.83 101.9,31.83 102.02,31.95 102.02,32.44 102.14,32.56 102.38,32.56 102.5,32.44 102.5,31.95 102.62,31.83 102.87,31.83 102.99,31.95 102.99,32.44 103.11,32.56 104.27,32.56 107.4,35.69 113.67,35.69 116.64,38.66 117.6,38.66 118.53,39.6 118.53,40.07 121.6,43.13 123.91,43.13 124.59,42.44 127.6,42.44 127.72,42.56 127.72,44.02 127.84,44.15 128.08,44.15 128.2,44.02 128.2,42.54 128.32,42.42 128.56,42.42 128.68,42.54 128.68,44.02 128.8,44.15 129.04,44.15 129.16,44.02 129.16,42.54 129.28,42.42 129.53,42.42 129.65,42.54 129.65,44.02 129.77,44.15 130.01,44.15 130.13,44.02 130.13,42.54 130.25,42.42 130.49,42.42 130.61,42.54 130.61,44.02 130.73,44.15 130.97,44.15 131.09,44.02 131.09,42.82 131.32,42.6 v1(132.49,42.6)
  BOTTOM w0.135: R230.2 132.71,42.37 v1(132.49,42.6)
PRG1_CPSW_RGMII2_RD3: length 74.6
  TOP w0.102: U18.V12 85.39,30.94 v2(85.36,30.9)
  TOP w0.135: U7.36 135.74,45.33 135.59,45.17 135.59,43.86 134.73,43 R72.1 134.94,42.24 135.28,42.24 v1(135.48,42.44)
  L03_SIG1 w0.102: v2(85.36,30.9) 85.42,30.96 86.19,30.96 86.31,31.08 87.6,31.08
  L03_SIG1 w0.121: v1(135.48,42.44) 135.01,41.97 134.76,41.97 134.64,42.09 134.64,43.57 134.49,43.71 134.28,43.71 134.15,43.59 134.15,42.26 134.03,42.14 133.79,42.14 133.67,42.26 133.67,43.57 133.53,43.71 133.31,43.71 133.19,43.59 133.19,42.09 133.06,41.96 129.97,41.96 129.85,41.84 129.85,41.5 129.73,41.38 129.49,41.38 129.37,41.5 129.37,41.84 129.25,41.96 129.01,41.96 128.88,41.84 128.88,41.5 128.76,41.38 128.52,41.38 128.4,41.5 128.4,41.84 128.28,41.96 128.04,41.96 127.92,41.84 127.92,41.5 127.8,41.38 127.56,41.38 127.44,41.5 127.44,41.84 127.32,41.96 127.07,41.96 126.95,41.84 126.95,41.5 126.83,41.38 126.59,41.38 126.47,41.5 126.47,41.84 126.35,41.96 122.78,41.96 119.99,39.17 119.48,39.17 118.59,38.28 118.59,35.57 117.92,34.9 109.03,34.9 106.25,32.12 106.25,31.06 105.52,30.34 102.58,30.34 101.8,29.57 100.28,29.57 98.15,31.7 88.22,31.7 87.6,31.08
  BOTTOM w0.135: v1(135.48,42.44) 134.79,42.44 R229.2
PRG1_CPSW_RGMII2_RSTN: length 5.1
  TOP w0.135: U7.43 140.18,42.52 v1(139.06,41.4)
  BOTTOM w0.135: v1(139.06,41.4) 138.57,41.4 138.45,41.28 U34.4
PRG1_CPSW_RGMII2_RX_CTL: length 74.4
  TOP w0.102: 87.49,31.36 U18.Y12
  TOP w0.135: 87.49,31.36 95.62,31.36 97.69,33.43 99.97,33.43 v1(100.63,34.09) ; U7.38 137.68,43.6 137.41,43.33 136.56,43.33 136.22,42.99 R73.2 136.44,42.24 136.73,42.24 v1(136.93,42.44)
  L03_SIG1 w0.121: v1(136.93,42.44) 134.34,45.03 133.17,45.03 132.9,44.76 127.7,44.76 126.7,45.76 121.33,45.76 121.12,45.56 121.12,45.39 121.99,44.52 121.99,44.35 121.85,44.2 121.63,44.2 120.78,45.05 120.61,45.05 120.44,44.88 120.44,44.71 121.3,43.85 121.3,43.68 121.14,43.52 120.94,43.52 120.1,44.36 119.93,44.36 119.76,44.19 119.76,44.02 120.59,43.19 120.59,43.02 120.43,42.86 120.24,42.86 119.42,43.68 119.25,43.68 119.08,43.51 119.08,43.34 119.9,42.52 119.9,42.35 119.73,42.18 119.55,42.18 118.94,42.8 118.77,42.8 118.54,42.57 118.54,40.84 118.21,40.51 117.63,40.51 117.22,40.11 117.22,39.6 116.87,39.24 116.41,39.24 113.37,36.2 106.86,36.2 105.33,34.67 101.22,34.67 v1(100.63,34.09)
  BOTTOM w0.135: R228.1 136.86,42.37 v1(136.93,42.44)
PRG1_CPSW_RGMII2_RXC: length 71.2
  TOP w0.102: v2(84.93,30.3) 84.98,30.36 U18.V10
  TOP w0.135: v1(132.18,46.61) 132.95,46.61 R51.1
  L03_SIG1 w0.121: v1(132.18,46.61) 134.19,46.61 136.35,44.45 136.35,43.79 137.54,42.6 137.54,41.36 136.34,40.17 131.79,40.17 130.92,41.04 122.96,41.04 120.98,39.07 120.98,36.55 118.82,34.39 110.99,34.39 104.56,27.97 103.48,27.97 102.85,28.6 96.8,28.6 95.63,29.77 87.6,29.77 87.35,30.02 85.21,30.02 v2(84.93,30.3)
PRG1_CPSW_RGMII2_RXC_R: length 2.8
  TOP w0.135: R51.2 134.5,46.62 135.21,47.33 U7.32
PRG1_CPSW_RGMII2_TD0: length 74.9
  TOP w0.102: 87.74,28.01 87.39,28.36 U18.Y6
  TOP w0.135: v1(112.83,37.52) 114.25,36.09 114.25,35.77 114.11,35.64 113.16,35.64 113.03,35.5 113.03,35.23 113.16,35.1 114.11,35.1 114.25,34.96 114.25,34.69 114.11,34.56 113.16,34.56 113.03,34.42 113.03,34.16 113.16,34.02 114.11,34.02 114.25,33.89 114.25,29.9 113.06,28.7 110.29,28.7 109.52,27.94 109.52,27.25 108.98,26.71 96.89,26.71 96.24,26.06 89.69,26.06 87.74,28.01 ; U7.28 135.06,49.33 134.66,49.73 v1(134.66,50.17)
  L03_SIG1 w0.121: v1(134.66,50.17) 133.99,50.84 129.94,50.84 129.42,50.32 122.86,50.32 115.27,42.72 115.27,41.76 112.83,39.32 v1(112.83,37.52)
PRG1_CPSW_RGMII2_TD1: length 75
  TOP w0.102: U18.AA8 87.09,29.16 87.73,29.16 87.74,29.15
  TOP w0.135: v1(135.52,49.83) 135.56,49.83 135.56,49.83 U7.27 ; v1(111.3,37.52) 106.87,33.08 104.33,33.08 102.62,31.37 102.62,30.3 100.79,28.47 96.9,28.47 96.16,27.74 89.15,27.74 87.74,29.15
  L03_SIG1 w0.121: v1(135.52,49.83) 136.42,49.83 136.63,49.63 136.63,49.26 136.51,49.14 134.53,49.14 134.41,49.02 134.41,48.77 134.53,48.65 134.88,48.65 135,48.53 135,48.28 135.12,48.16 135.36,48.16 135.49,48.28 135.49,48.53 135.61,48.65 136.51,48.65 136.63,48.53 136.63,47.36 136.48,47.22 133.63,47.22 133.27,47.58 133.27,50.17 132.85,50.59 130.32,50.59 129.77,50.04 124.41,50.04 122.89,48.51 121.51,48.51 115.57,42.57 115.57,41.63 113.94,40.01 113.94,37.86 113.07,36.99 111.83,36.99 v1(111.3,37.52)
PRG1_CPSW_RGMII2_TD2: length 75
  TOP w0.102: 87.31,29.86 U18.Y9
  TOP w0.135: v1(108.25,37.52) 104.37,33.63 103.66,33.63 99.25,29.23 88.66,29.23 88.14,29.74 87.43,29.74 87.31,29.86 ; v1(134.6,51.5) 134.6,51.05 135.32,50.33 U7.26
  L03_SIG1 w0.121: v1(134.6,51.5) 130.06,51.5 129.14,50.58 122.74,50.58 114.96,42.79 114.96,42.01 111.58,38.63 101.54,38.63 101.37,38.46 101.37,37.69 101.54,37.52 v1(108.25,37.52)
PRG1_CPSW_RGMII2_TD3: length 75.2
  TOP w0.102: U18.W9 85.89,29.44 v2(85.93,29.39)
  TOP w0.135: v1(135.52,51.5) 135.52,51.06 135.74,50.83 U7.25
  L03_SIG1 w0.121: v1(135.52,51.5) 137.29,49.73 137.29,47.47 138.84,45.92 138.84,41.94 136.56,39.66 131.06,39.66 130.56,40.15 125.04,40.15 123.67,38.79 123.67,36.83 120.6,33.76 113.39,33.76 112.79,33.16 110.53,33.16 109.65,32.28 109.65,30.52 106.54,27.41 103.3,27.41 102.62,28.09 96.22,28.09 95.05,29.26 87.17,29.26 87.04,29.39 v2(85.93,29.39)
PRG1_CPSW_RGMII2_TX_CTL: length 74.8
  TOP w0.102: U18.V9 85.39,29.44 v2(85.36,29.39)
  TOP w0.135: v1(137.19,43.78) 137.19,43.84 137.18,43.84 U7.37
  L03_SIG1 w0.121: v1(137.19,43.78) 137.19,44.22 135.01,46.4 135.01,46.67 135.25,46.91 137.48,46.91 138.58,45.82 138.58,42.04 136.45,39.91 131.46,39.91 130.96,40.41 124.77,40.41 122.28,37.91 122.28,36.71 119.58,34.02 113.19,34.02 112.59,33.42 110.38,33.42 109.22,32.26 109.22,31.28 105.65,27.71 103.37,27.71 102.74,28.34 96.47,28.34 95.3,29.52 87.43,29.52 87.18,29.76 85.73,29.76 v2(85.36,29.39)
PRG1_CPSW_RGMII2_TXC: length 8
  TOP w0.102: U18.Y8 86.67,29.64 87.15,29.64 87.35,29.44 87.74,29.44
  TOP w0.135: R23.1 93.72,28.38 93.25,28.86 88.59,28.86 88.01,29.44 87.74,29.44
PRG1_CPSW_RGMII2_TXC_R: length 67
  TOP w0.135: v1(109.78,37.52) 105.62,33.36 103.82,33.36 99.34,28.88 96.62,28.88 96.09,28.35 R23.2 ; U7.29 135.14,48.83 134.09,49.89 v1(132.61,49.89)
  L03_SIG1 w0.121: v1(109.78,37.52) 110.56,36.73 113.18,36.73 114.27,37.83 114.27,39.93 115.82,41.48 115.82,41.52 115.83,41.52 115.83,42.42 119.86,46.46 123.46,46.46 123.58,46.58 123.58,48.14 123.73,48.29 123.92,48.29 124.06,48.14 124.06,46.58 124.18,46.46 124.4,46.46 124.52,46.58 124.52,48.16 124.64,48.29 124.88,48.29 125,48.16 125,46.6 125.15,46.46 125.36,46.46 125.48,46.58 125.48,48.16 125.6,48.29 125.85,48.29 125.97,48.16 125.97,46.6 126.11,46.46 126.33,46.46 126.45,46.58 126.45,48.16 126.57,48.29 126.84,48.29 126.96,48.16 126.96,46.58 127.15,46.38 127.56,46.38 131.06,49.89 v1(132.61,49.89)
PRG1_CPSW_RGMII_INTN: length 93.4
  TOP w0.102: 87.74,32 87.03,32 U18.AA13
  TOP w0.135: v1(140.69,43) 140.68,43.01 U7.44 ; v1(142.39,23.39) 142.21,23.22 141.85,23.22 R136.2 141.66,23.88 140.68,24.85 U19.44 ; 87.74,32 94.94,32 94.94,32 95,32 97.74,34.75 100.59,34.75 101.79,33.55 102.36,33.55 102.74,33.93 102.74,34.96 103.52,35.73 105.71,35.73 108.05,38.07 113.67,38.07 115.47,36.26 122.69,36.26 v1(123.32,35.64)
  L03_SIG1 w0.121: v1(140.69,43) 140.69,42.34 137.64,39.29 130.86,39.29 130.26,39.9 125.35,39.9 124.1,38.66 124.1,36.42 v1(123.32,35.64)
  BOTTOM w0.135: v1(142.39,23.39) 136.69,29.1 136.69,38.49 137.85,39.65 138.87,39.65 139.5,40.28 139.5,41.35 140.69,42.55 v1(140.69,43)
PRG1_IEP0_EDC_LATCH_IN0: length 33.4
  TOP w0.102: U18.Y4 86.67,27.08 87.14,27.08 87.58,26.65 87.58,26.64 87.74,26.49
  TOP w0.135: v1(98.73,24.18) 98.15,24.77 89.46,24.77 89.42,24.8 87.74,26.49
  BOTTOM w0.135: J5.8 109.02,18.85 99.01,18.85 98.47,19.39 98.47,23.92 v1(98.73,24.18)
PRG1_IEP0_EDC_LATCH_IN1: length 53.6
  TOP w0.102: U18.V13 85.41,31.86 v2(85.93,32.38)
  L03_SIG1 w0.102: 87.74,33.17 87.44,33.17 86.65,32.38 v2(85.93,32.38)
  L03_SIG1 w0.121: v1(114.88,35.79) 114.53,35.44 108.59,35.44 104.9,31.75 104.9,31.47 104.52,31.09 100.8,31.09 98.72,33.17 87.74,33.17
  BOTTOM w0.135: v1(114.88,35.79) 114.88,20.55 116.95,18.49 J5.12
PRG1_IEP0_EDC_SYNC_OUT0: length 33.5
  TOP w0.102: U18.U3 85.31,26.86 v2(85.36,26.82)
  L03_SIG1 w0.121: v2(85.36,26.82) 85.89,26.29 87.71,26.29 88.32,25.68 v1(98.73,25.68)
  BOTTOM w0.135: J5.6 107.9,17.42 101.04,17.42 100.15,18.31 99.01,18.31 98.2,19.12 98.2,25.15 v1(98.73,25.68)
PRG1_IEP0_EDC_SYNC_OUT1: length 36.2
  TOP w0.102: U18.T2 84.11,26.08 84.11,25.64 84.41,25.34 84.41,25.02
  TOP w0.135: v1(99.01,19.61) 88.29,19.61 86.44,21.46 86.44,22.78 84.41,24.81 84.41,25.02
  BOTTOM w0.135: v1(99.01,19.61) 110.8,19.61 J5.10
PRG1_MDIO0_MDC: length 102.9
  TOP w0.102: U18.W1 86.23,25.53
  TOP w0.135: v1(91.92,23.34) 91.39,23.88 87.88,23.88 86.23,25.53 ; U7.42 139.68,43.77 v1(139.67,43.76) ; U19.42 v1(139.68,24.62)
  L03_SIG1 w0.121: v1(91.92,23.34) 92.35,23.77 97.48,23.77 100.07,21.18 132.02,21.18 133.08,20.12 137.72,20.12 138.61,21.01 138.61,24.82 137.69,25.73 137.69,31.19 138.18,31.67 141.4,31.67 142.04,31.04 142.04,26.97 v1(139.68,24.62)
  BOTTOM w0.135: v1(139.67,43.76) 139.99,43.45 139.99,42.38 139.52,41.91 138.66,41.91 136.42,39.67 136.42,27.88 v1(139.68,24.62)
PRG1_MDIO0_MDIO: length 89.4
  TOP w0.102: 85.41,25.44 85.39,25.45 U18.V2
  TOP w0.114: 85.83,25.02 85.41,25.44
  TOP w0.135: 85.83,25.02 87.99,22.86 v1(89.74,22.86) ; R135.2 139.44,23.4 v1(139.42,23.42) 139.18,23.66 U19.41 ; U7.41 139.18,43.33 139.42,43.09 v1(139.42,42.65)
  L03_SIG1 w0.121: v1(89.74,22.86) 90.27,22.33 90.27,21.81 90.67,21.41 91.16,21.41 92.42,22.68 97.85,22.68 100.45,20.07 111.82,20.07 112.27,20.52 131.72,20.52 132.74,19.51 138.07,19.51 139.42,20.85 v1(139.42,23.42)
  BOTTOM w0.135: v1(139.42,42.65) 139.01,42.65 136.15,39.78 136.15,26.69 v1(139.42,23.42)
PRG1_RGMII1_RD0: length 25.9
  TOP w0.102: v2(85.93,26.82) 85.93,26.82 85.93,26.82 U18.V4
  L03_SIG1 w0.121: v2(85.93,26.82) 87.81,26.82 88.52,26.11 99.11,26.11 99.8,25.43 101.07,25.43 101.19,25.55 101.19,25.89 101.08,26.01 v1(100.63,26.01)
  BOTTOM w0.135: v1(100.63,26.01) 100.63,25.41 100.85,25.2 101.47,25.2 101.68,25.41 101.68,26.06 104.45,28.84 U40.29
PRG1_RGMII1_RD1: length 25.9
  TOP w0.102: U18.W5 85.89,27.41 v2(85.93,27.38)
  L03_SIG1 w0.121: v2(85.93,27.38) 87.82,27.38 88.77,26.47 88.92,26.47 88.95,26.43 101.18,26.43 101.96,25.65 101.96,25.27 102.92,24.31 103.25,24.31 103.56,24.61 103.56,24.89 v1(102.59,25.86)
  BOTTOM w0.135: U40.27 104.57,27.84 v1(102.59,25.86)
PRG1_RGMII1_RD2: length 25.9
  TOP w0.102: U18.AA4 87.24,27.36 87.74,26.87
  TOP w0.135: 87.74,26.87 89.54,25.07 103.66,25.07 103.89,24.84 103.89,24.03 103.62,23.76 102.7,23.76 v1(102.26,24.21)
  BOTTOM w0.135: v1(102.26,24.21) 104.89,26.84 U40.25
