# Allegro board PROC109E2_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VSYS_5V0_CT: length 2.4
  TOP w0.203: C69.1 33.02,22.42 32.75,22.69 U23.6
VSYS_5V0_ON: length 33.6
  TOP w0.254: U15.4 16.27,35.06 16.54,34.8 LD9.1 v1(17.15,34.17) ; v1(28.93,22.61) 29.01,22.68 29.06,22.68 29.06,22.69 U23.3
  L03_SIG1 w0.203: v1(17.15,34.17) 15.94,35.38 14.71,35.38 13.87,34.54 13.87,27.66 14.73,26.8 22.81,26.8 23.39,26.21 23.39,23.29 24.08,22.61 v1(28.93,22.61)
VUSB_5V0: length 55.4
  TOP w0.135: v1(24.21,26.29) 23.04,27.46 v1(15.12,27.46)
  TOP w0.178: 10.26,27.79 U20.12
  TOP w0.254: 28.88,23.34 29.04,23.19 U23.2 ; U23.4 29.2,22.19 29.07,22.06 28.68,22.06 28.42,22.31 28.42,23.14 ; 10.26,27.79 10.21,27.84 C57.1 9.3,28.37 v1(9.3,28.42) ; C42.1 16.07,36.22 15.91,36.06 U15.5 ; U23.1 29.02,23.69
  TOP w0.33: v1(17.27,36.22) 16.56,36.22 C42.1 ; v1(14.63,30.48) 14.79,30.48 15.12,30.15 R110.2
  TOP w0.381: R94.1 17.71,35.78 v1(17.27,36.22) ; R113.2 v1(15.12,27.46) ; R106.2 R105.2 10.55,31.94 v1(10.19,31.57) ; v1(4.34,26.8) 4.29,26.75 v1(3.07,26.75) v1(1.8,26.75)
  L03_SIG1 w0.508: v1(9.3,28.42) 9.3,30.68 v1(10.19,31.57)
  L04_PWR1 w0.381: v1(10.19,31.57) 10.19,34.11 12.29,36.22 v1(17.27,36.22)
  L04_PWR1 w0.508: v1(4.34,26.8) 7.67,26.8 v1(9.3,28.42)
  BOTTOM w0.33: C226.1 3.81,27.3
  BOTTOM w0.381: v1(10.19,31.57) 11.28,30.48 v1(14.63,30.48) 14.63,27.95 v1(15.12,27.46)
WDI: length 3.1
  TOP w0.135: R9.2 v1(13.84,56.62)
  BOTTOM w0.135: U27.20 13.97,55.08 13.84,55.21 v1(13.84,56.62)
WDO: length 2.3
  TOP w0.135: v1(13.49,54.12) 13.09,54.51 R11.2
  BOTTOM w0.135: U27.19 13.95,54.58 v1(13.49,54.12)
XDS110_DEBUG_ID4: length 3.7
  TOP w0.135: R98.1 v1(20.5,30.51)
  BOTTOM w0.135: v1(20.5,30.51) 21.21,29.79 21.21,29.01 21.1,28.9 U37.63
XDS110_DEBUG_ID5: length 3.6
  TOP w0.135: R99.1 v1(22.05,30.51)
  BOTTOM w0.135: v1(22.05,30.51) 21.5,29.96 U37.62
XDS110_DEBUG_ID6: length 4.3
  TOP w0.135: R100.1 v1(23.52,30.51)
  BOTTOM w0.135: U37.61 21.9,29.34 23.07,30.51 v1(23.52,30.51)
XDS110_DEBUG_ID7: length 5.3
  TOP w0.135: R101.1 v1(24.99,30.51)
  BOTTOM w0.135: U37.60 22.3,29.16 23.11,29.97 24.46,29.97 v1(24.99,30.51)
XDS110_EMU0: length 7.8
  TOP w0.135: U16.8 28.51,33.64 29.06,33.1 29.06,30.06 29.26,29.86 R109.1 v1(29.84,29.18)
  BOTTOM w0.135: v1(29.84,29.18) 29.64,29.18 29.5,29.05 U37.42
XDS110_EMU1: length 12.2
  TOP w0.135: R108.1 v1(28.37,29.18) 29.06,28.5 31.5,28.5 32.03,29.03 32.03,33.23 31.62,33.64 U16.1
  BOTTOM w0.135: U37.43 29.1,29.01 28.93,29.18 v1(28.37,29.18)
XDS110_PROG_STAZ1: length 35.2
  TOP w0.135: R114.2 v1(6.5,27.58)
  L03_SIG1 w0.121: v1(33.38,40.69) 32.57,39.88 20.29,39.88 19.43,39.01 16.18,39.01 7.16,30 7.16,28.24 v1(6.5,27.58)
  BOTTOM w0.135: U37.4 34.6,40.69 v1(33.38,40.69)
XDS110_PROG_STAZ2: length 36.8
  TOP w0.135: v1(6.25,30.58) 5.82,30.16 R111.2
  L03_SIG1 w0.121: v1(35.83,41.09) 35.74,41.17 33.12,41.17 32.09,40.14 19.92,40.14 19.05,39.27 14.69,39.27 8.61,33.19 8.61,32.94 v1(6.25,30.58)
  BOTTOM w0.135: v1(35.83,41.09) 35.82,41.09 U37.3
XDS110_TCK: length 44.4
  TOP w0.135: v1(70.33,24.21) 70.04,23.91 U25.13
  L03_SIG1 w0.121: v1(70.33,24.21) 69.91,24.62 68.52,24.62 67.23,25.91 66.31,25.91 64.62,27.6 64.62,28.41 62.22,30.8 50.66,30.8 48.9,29.04 32.91,29.04 v1(32.79,29.16)
  BOTTOM w0.135: U37.35 32.3,28.91 32.56,29.16 v1(32.79,29.16)
XDS110_TDI: length 49.3
  TOP w0.135: U25.12 v1(70.69,21.01)
  L03_SIG1 w0.121: v1(70.69,21.01) 70.69,21.72 69.52,22.89 68.97,22.89 64.34,27.52 64.34,28.33 62.81,29.86 50.18,29.86 48.09,27.77 39.29,27.77 38.76,28.3 31.65,28.3 v1(30.76,29.18)
  BOTTOM w0.135: v1(30.76,29.18) 31.1,28.84 U37.38
XDS110_TDO: length 50.6
  L03_SIG1 w0.121: v1(30.76,30.1) 30,30.1 29.18,29.29 29.18,26.54 29.59,26.14 30.17,26.14 30.45,26.42 30.45,26.95 31.16,27.66 37.42,27.66 38.39,26.69 44.13,26.69 45.04,25.78 59.59,25.78 60.78,24.59 v1(60.78,21.34)
  BOTTOM w0.135: U42.7 65.52,20.57 65.27,20.32 64.43,20.32 64.14,20.32 63.11,21.34 v1(60.78,21.34) ; U37.37 31.5,29.36 v1(30.76,30.1)
XDS110_TMS: length 46.8
  TOP w0.135: U25.11 71.34,24.09 v1(71.48,24.23)
  L03_SIG1 w0.121: v1(71.48,24.23) 70.74,24.97 68.63,24.97 67.34,26.26 66.32,26.26 64.87,27.71 64.87,28.51 62.33,31.06 50.21,31.06 49.28,30.12 38.68,30.12 37.86,29.3 33.49,29.3 v1(32.72,30.07)
  BOTTOM w0.135: v1(32.72,30.07) 31.9,29.26 U37.36
XDS110_TRST#: length 53.3
  TOP w0.135: v1(72.01,21.54) 71.99,21.56 U25.10
  L03_SIG1 w0.121: v1(29.92,26.64) 29.92,27.36 30.48,27.91 37.59,27.91 38.31,27.2 44.12,27.2 44.82,26.5 47.48,26.5 50.58,29.6 62.7,29.6 64.06,28.24 64.06,27.38 69.26,22.18 69.26,21.14 70,20.4 70.87,20.4 v1(72.01,21.54)
  BOTTOM w0.135: v1(29.92,26.64) 30.3,27.03 U37.40
XDS110_UART1_RXD: length 17.6
  L03_SIG1 w0.121: v1(33.88,26.75) 37.67,26.75 39.65,24.77 v1(39.65,23.77)
  BOTTOM w0.135: U45.13 34.28,21.51 34.57,21.8 38.51,21.8 39.65,22.94 v1(39.65,23.77) ; v1(33.88,26.75) 33.33,26.75 33.1,26.98 U37.33
XDS110_UART1_TXD: length 17.6
  L03_SIG1 w0.121: v1(38.38,23.85) 38.38,25.48 37.57,26.29 32.87,26.29 v1(32.72,26.44)
  BOTTOM w0.135: U37.34 32.7,26.45 v1(32.72,26.44) ; U45.11 32.98,21.48 33.58,22.07 37.74,22.07 38.38,22.71 v1(38.38,23.85)
XDS110_VBUS_DET: length 21
  L03_SIG1 w0.121: v1(28.57,41.94) 24.82,45.69 v1(18.29,45.69)
  BOTTOM w0.135: U37.1 33.58,41.89 33.1,41.4 29.11,41.4 v1(28.57,41.94)
  BOTTOM w0.508: R219.2 R212.1 17.58,46.41 v1(18.29,45.69)
XDS_RBIAS: length 2.6
  BOTTOM w0.178: U37.59 22.7,26.83 23.05,26.48 23.05,25.71 R256.1
XDS_RESET#: length 6
  TOP w0.135: TP26.1 15.93,33.43 v1(17.73,33.43)
  BOTTOM w0.135: U37.70 18.12,31.49 17.73,31.88 v1(17.73,33.43) R246.2
XDS_SHIELD:
  vias: v1(4.85,16.05) v1(4.85,14.78) v1(6.12,16.05) v1(6.12,14.78) v1(7.39,16.05) v1(7.39,14.78)
XDS_USB_D_N: length 35.3
  TOP w0.107: J20.2 6.52,21.73 6.73,21.52 7.59,21.52 7.73,21.66 U24.4 U24.7 9.5,21.66 9.64,21.52 10.06,21.52 v1(10.4,21.86)
  L03_SIG1 w0.102: v1(20.52,39.01) 20.86,38.67 20.86,37.89 20.47,37.49 18.9,37.49 18.36,38.02 17.75,38.02 17.22,37.49 16.73,37.49 15.85,36.6 14.5,36.6 12.24,34.34 12.24,22.51 11.27,21.53 10.73,21.53 v1(10.4,21.86)
  BOTTOM w0.107: v1(20.52,39.01) 20.52,38.82 20.63,38.71 20.85,38.71 20.96,38.82 20.96,40.23 20.42,40.77 20.15,40.77 20.07,40.69 U37.93
XDS_USB_D_P: length 35.3
  TOP w0.107: J20.3 6.52,21.08 6.73,21.29 7.59,21.29 7.73,21.16 U24.5 U24.6 9.5,21.16 9.64,21.29 10.06,21.29 v1(10.4,20.95)
  L03_SIG1 w0.102: v1(10.4,20.95) 10.73,21.28 11.37,21.28 12.5,22.4 12.5,34.24 14.61,36.35 15.95,36.35 16.84,37.24 17.33,37.24 17.86,37.77 18.26,37.77 18.79,37.24 20.57,37.24 21.12,37.78 21.12,38.67 v1(21.46,39.01)
  BOTTOM w0.107: U37.94 20.02,41.09 20.1,41 20.52,41 21.19,40.33 21.19,39.29 v1(21.46,39.01)
XDS_USB_ID: length 32.3
  TOP w0.135: U24.9 v1(9.66,22.66)
  TOP w0.178: U24.9 U24.2 7.82,22.66 v1(7.47,22.3)
  TOP w0.254: J20.4 v1(6.89,20.43)
  L03_SIG1 w0.121: v1(9.66,22.66) 8.71,23.61 8.71,26.21 7.87,27.05 6.1,27.05 5.56,27.58 5.56,30.68 14.25,39.37 v1(14.25,40.82)
  L03_SIG1 w0.127: v1(6.89,20.43) 7.47,21.01 v1(7.47,22.3)
  BOTTOM w0.135: v1(14.25,40.82) 14.7,40.82 14.82,40.94 R231.2
XDS_VREF: length 5.8
  BOTTOM w0.178: U37.9 36.63,38.69 C129.1
  BOTTOM w0.33: 38.86,38.59 38.82,38.63 C128.1 C129.1
  BOTTOM w0.381: U36.3 R235.2 38.86,38.59
N17247526: length 1.4
  TOP w0.135: LD15.2 v1(182.88,9.3)
  BOTTOM w0.135: R282.2 v1(182.88,9.3)
N17247539: length 1.4
  TOP w0.135: LD14.2 v1(181.38,9.3)
  BOTTOM w0.135: R283.2 v1(181.38,9.3)
N17247599: length 1.4
  TOP w0.135: LD13.2 v1(179.88,9.3)
  BOTTOM w0.135: R284.2 v1(179.88,9.3)
N17247637: length 1.4
  TOP w0.135: LD12.2 v1(178.38,9.3)
  BOTTOM w0.135: R285.2 v1(178.38,9.3)
N29126233: length 2.6
  TOP w0.135: R67.1 24.79,44.32 24.16,44.96 SW4.11
N29126235: length 2.5
  TOP w0.135: SW4.12 24.18,46.23 24.59,45.82 R53.1
N29126237: length 2.4
  TOP w0.135: SW4.13 24.41,47.5 24.59,47.32 R48.1
N29126239: length 2.3
  TOP w0.135: SW4.14 24.41,48.77 24.46,48.82 R34.1
N29126243: length 2.7
  TOP w0.135: SW4.10 24,43.69 24.87,42.82 R70.1
N29126245: length 2.4
  TOP w0.135: R28.1 24.74,50.32 24.46,50.04 SW4.15
N29126269: length 2.5
  TOP w0.135: R17.1 25.4,51.78 24.93,51.31 SW4.16
N30174920: length 3.2
  BOTTOM w0.135: R179.2 R180.2 76.56,53.06 76.69,52.93 U31.2
N30212600: length 9.4
  TOP w0.135: v1(174.49,59.07) 175.97,59.07 177.94,61.05 LD2.1
  BOTTOM w0.135: Q5.2 Q5.1 ; Q5.1 174.49,60.38 Q5.8 174.49,61.03 Q5.6 Q5.5 ; Q5.1 v1(174.49,59.07)
N30212640: length 1.3
  TOP w0.135: v1(176.39,63.7) 176.39,63.69 176.38,63.67 LD1.2
  BOTTOM w0.135: v1(176.39,63.7) 176.39,63.04 R167.2
N30212699: length 12.1
  TOP w0.135: v1(169.67,59.07) 172.39,59.07 175.36,62.04 LD1.1
  BOTTOM w0.135: Q6.1 169.67,60.38 Q6.8 169.67,61.03 Q6.6 Q6.5 ; Q6.1 Q6.2 ; Q6.1 v1(169.67,59.07)
N30213674: length 1.3
  TOP w0.135: v1(177.95,63.69) 177.95,63.68 177.94,63.66 LD2.2
  BOTTOM w0.135: R166.2 v1(177.95,63.69)
N30217069: length 3.6
  BOTTOM w0.178: U37.96 17.82,41.89 17.57,42.14 C114.1
  BOTTOM w0.33: R222.1 17.31,42.72 17.1,42.51 C114.1
N30217074: length 2.1
  BOTTOM w0.135: R231.1 17.85,41.49 U37.95
N30217111: length 1.4
  TOP w0.135: LD10.2 R111.1
N30217160: length 1.4
  TOP w0.135: LD11.2 R114.1
N30310219: length 2.7
  TOP w0.381: R118.1 R117.2 35.95,28.29 D3.3
N30339679: length 27.9
  TOP w0.135: U1.1 29.73,58.59 30,58.31 30,57.36 27.46,54.81 27.46,54.2 26.29,53.03 25.16,53.03 24.73,52.6 24,52.6 22.84,53.77 21.79,53.77 20.4,52.37 v1(14.71,52.37) 13.82,53.26 R15.1
  BOTTOM w0.135: v1(14.71,52.37) 15.05,52.03 U27.15 ; v1(14.71,52.37) 14.69,52.39 U27.16 ; v1(14.71,52.37) 14.18,52.37 13.84,52.71 13.84,53.82 14.1,54.08 U27.18
N30360253: length 14.6
  TOP w0.135: U19.48 142.68,25.02 142.87,24.84 v1(143.37,24.84) ; TP25.1 142.68,34.75 v1(142.68,33.4) U19.13
  BOTTOM w0.135: v1(142.68,33.4) 140.69,31.41 140.69,26.57 142.42,24.84 v1(143.37,24.84)
N30371240: length 4.2
  BOTTOM w0.135: R258.2 167.03,31.19 J19.14
N30372374: length 4.4
  BOTTOM w0.135: C264.2 172.69,16.84 171.94,17.6 J19.12
N30372789: length 2.5
  BOTTOM w0.135: C261.2 J19.6
N30372794: length 2.4
  BOTTOM w0.135: J19.1 C195.2
N30372799: length 1.9
  BOTTOM w0.135: J19.7 C164.2
N30391563: length 3.6
  BOTTOM w0.135: J18.14 168.02,50.67 166.9,51.79 R210.2
N30391600: length 4.5
  BOTTOM w0.135: C127.2 173.07,38.41 171.94,39.54 J18.12
N30391628: length 2.7
  BOTTOM w0.135: C115.2 J18.6
N30391632: length 2.4
  BOTTOM w0.135: J18.1 C89.2
N30391636: length 1.9
  BOTTOM w0.135: J18.7 C83.2
N30391831: length 14
  TOP w0.135: U7.13 v1(142.68,52.45) 142.68,53.8 TP4.1 ; U7.48 142.68,43.98 142.8,43.87 v1(143.33,43.87)
  BOTTOM w0.135: v1(143.33,43.87) 140.77,46.43 140.77,50.54 v1(142.68,52.45)
N30573184: length 1.3
  TOP w0.135: R79.2 LD6.2
N30625746: length 12.9
  TOP w0.102: U18.B5 77.11,27.58 76.55,27.58 76.2,27.24
  TOP w0.135: 76.2,27.24 75.86,26.9 75.86,26.26 73.38,23.77 73.38,20.95 v1(72.36,19.94)
  BOTTOM w0.135: R271.2 v1(72.36,19.94)
N30693218: length 2
  TOP w0.135: v1(181.55,61.44) 181.44,61.34 180.99,61.34 180.99,61.33 LD3.3
  BOTTOM w0.135: v1(181.55,61.44) 180.86,61.44 R168.2
N30693408: length 1.6
  TOP w0.135: v1(178.62,61.45) 178.74,61.33 LD3.2
  BOTTOM w0.135: R169.2 v1(178.62,61.45)
N30703604: length 1.3
  TOP w0.135: LD7.2 R86.2
N30743471: length 1.5
  TOP w0.135: LD5.2 R18.2
N30743502: length 5.1
  TOP w0.135: Q2.2 Q2.1 1.76,47.7 Q2.8 1.76,48.35 Q2.6 ; Q2.6 LD5.1 ; Q2.6 Q2.5
N30743652: length 1.5
  TOP w0.135: LD4.2 R7.2
N30743676: length 5.1
  TOP w0.135: Q1.6 1.76,54.45 Q1.8 1.76,53.8 Q1.1 Q1.2 ; Q1.6 LD4.1 ; Q1.6 Q1.5
N30811240: length 8.4
  TOP w0.135: LD3.4 180.35,62.94 182.03,62.94 183.49,61.48 v1(183.49,60.98)
  BOTTOM w0.135: v1(183.49,60.98) Q9.5 Q9.6 184.14,59.71 Q9.8 183.82,59.34 184.14,59.01 Q9.1 Q9.2
N30811389: length 10.8
  TOP w0.135: v1(184.14,61.65) 184.14,62.21 182.52,63.83 179.67,63.83 179.44,63.6 LD3.1
  BOTTOM w0.135: Q4.1 v1(184.14,61.65) ; Q4.1 184.14,62.92 Q4.8 184.14,63.57 Q4.6 Q4.5 ; Q4.1 Q4.2
N30900913: length 6.5
  TOP w0.102: 76.05,32.86 U18.A15
  TOP w0.135: 76.05,32.86 72.88,32.86 v1(72.7,33.03)
  BOTTOM w0.135: v1(72.7,33.03) 72.7,33.73 R244.1 72.7,35.08 R240.1
N30979572: length 1.8
  TOP w0.135: U25.4 70.04,16.45 70.31,16.18 R162.2
N31410611: length 1.3
  TOP w0.135: R91.2 LD8.2
N31410626: length 4.8
  TOP w0.135: Q3.2 Q3.1 1.71,34.09 Q3.8 1.71,34.74 Q3.6 ; Q3.6 1.71,35.89 1.72,35.9 LD8.1 ; Q3.6 Q3.5
N31458583: length 2.4
  TOP w0.135: R119.2 13.59,26.72 13.39,26.93 13.39,27.4 13,27.79 U20.3
N31483389: length 1.3
  TOP w0.254: LD9.2 R94.2
N32041451: length 3.1
  TOP w0.254: R31.2 58.05,49.98 58.48,49.54 U5.4

## Copper pours and planes (outline as drawn)
DGND on L03_SIG1 (solid shape): 159.24,35.62 159.31,35.72 159.42,35.7 160.22,34.89 160.22,25.65 160.16,25.56 160.05,25.58 159.24,26.39
DGND on L03_SIG1 (solid shape): 77.11,22.57 77.22,22.59 77.28,22.5 77.28,20.45 77.89,19.84 77.89,19.72 77.83,19.72 77.82,19.73 77.62,19.75 77.43,19.67 77.36,19.64 77.29,19.67 77.06,19.91 77.06,22.51
DGND on L03_SIG1 (solid shape): 82.28,24.76 82.34,24.85 82.45,24.83 83.38,23.9 83.38,19.41 84.38,18.41 85.32,18.41 85.39,18.38 85.43,18.31 85.43,18.27 85.44,18.23 85.42,18.14 85.34,18.1 84.53,18.1 82.28,20.35
DGND on L03_SIG1 (solid shape): 141.67,30.89 141.67,27.13 139.5,24.96 139.5,24.95 139.34,24.78 139.31,24.54 139.29,24.46 139.21,24.42 139.14,24.42 139.03,24.4 138.97,24.49 138.97,24.97 138.06,25.88 138.06,31.04 138.33,31.31 141.25,31.31
DGND on L03_SIG1 (solid shape): 65.24,28.09 65.3,28.18 65.41,28.16 65.66,27.91 65.97,27.91 66.04,27.88 66.07,27.82 66.32,27.48 66.73,27.58 66.8,27.61 66.87,27.58 68.54,25.91 68.57,25.83 68.53,25.76 68.51,25.74 68.44,25.71 68.37,25.74 67.49,26.63 66.47,26.63 65.24,27.86
DGND on L03_SIG1 (solid shape): 9.09,16.1 9.16,16.2 9.27,16.18 10.71,14.73 10.71,10.47 12.62,8.55 38.43,8.55 39.24,9.36 64.87,9.36 65.88,8.35 65.91,8.24 65.81,8.18 65.56,8.18 65.48,8.22 65.46,8.31 65.1,8.81 64.74,8.31 64.73,8.22 64.64,8.18 27.74,8.18 11.07,8.11 9.09,10.08
DGND on L03_SIG1 (solid shape): 78.82,13.87 78.92,13.79 78.88,13.68 77.35,11.09 78.6,8.36 78.63,8.25 78.54,8.18 72.55,8.18 71.68,8.81 70.81,8.18 66.78,8.18 66.69,8.22 66.68,8.31 66.68,8.57 66.51,8.76 66.5,8.77 66.36,8.9 66.34,9.02 66.44,9.08 69.01,9.08 70.6,10.67 70.71,10.69 70.77,10.6 72.33,10 71.73,11.56 71.64,11.62 71.66,11.73 73.79,13.87
DGND on L03_SIG1 (solid shape): outline of 406 points within 68.09,15.87 78.44,26.09
DGND on TOP: 72.95,39.87 72.95,37.63 73.37,37.21 74.78,37.21 76.76,35.23 77.06,35.23 77.52,35.69 77.52,35.94 77.01,36.45 76.71,36.45 74.69,38.47 74.26,38.47 73.52,39.21 73.52,39.87
DGND on TOP: 50.8,46.28 50.68,46.16 50.68,45.78 50.5,45.6 49.77,45.6 49.76,45.59 46.97,45.59 46.59,45.97 46.59,46.86 46.33,47.12 45.83,47.12 45.7,46.99 45.7,45.21 45.06,45.21 44.68,44.83 44.68,43.82 44.57,43.7 39.63,43.7 39.37,43.43 39.37,40.77 39.62,40.51 42.42,40.51 42.86,40.96 42.86,42.73 43.31,43.18 44.35,43.18 44.35,40.84 44.56,40.64 45.49,40.64 46.2,41.35 53.39,41.35 53.8,41.76 53.8,45.8 53.31,46.28
DGND on TOP: 48.74,36.88 49.57,36.88 50.14,37.45 55.36,37.45 55.5,37.59 55.5,37.91 55.32,38.09 54.83,38.09 54.82,38.08 50.02,38.08 49.53,37.59 48.76,37.59 48.67,37.5 48.67,36.96
DGND on TOP: 110.81,53.16 118.7,53.16 119.32,52.55 119.32,46.3 118.79,45.77 110.92,45.77 110.43,46.26 110.43,52.78 ; 1 cut-out
DGND on TOP: 4.85,19.89 4.85,19.27 5.56,18.56 7.63,18.56 8.36,17.83 10.19,17.83 10.46,18.11 10.46,19.8 10.17,20.09 5.05,20.09
DGND on TOP: 74.68,40.52 74.68,39.97 75.19,39.45 75.53,39.45 76.48,38.51 76.48,38.14 76.65,37.97 76.87,37.97 76.96,38.06 76.96,39.8 76.24,40.52
DGND on TOP: 100.22,55.34 97.99,55.34 97.79,55.54 97.79,56.92 97.97,57.1 100.2,57.1 100.31,56.99 100.31,55.43
DGND on BOTTOM: 86.12,35.82 86.76,36.47 89.05,36.47 89.36,36.78 89.36,39.04 89.13,39.27 86.13,39.27 85.67,38.81 85.67,35.88 85.73,35.82
DGND on BOTTOM: 124.24,26 124.24,31.36 124.43,31.55 125.58,31.55 126.09,32.06 127.13,32.06 127.3,32.24 127.3,32.94 127.17,33.08 123.47,33.08 122.91,32.51 122.91,28.88 122.2,28.18 116.42,28.18 116.16,27.92 116.16,25.87 116.43,25.6 123.85,25.6
DGND on BOTTOM: 78.03,26.44 78.12,26.34 78.12,23.9 78.29,23.74 78.29,22.31 78.23,22.25 76.45,22.25 76.17,22.53 76.17,25.29 77.32,26.44
DGND on BOTTOM: 31.11,13.74 33.78,13.74 33.96,13.92 33.96,16.31 34.39,16.74 38.33,16.74 38.46,16.86 38.46,18.36 38.35,18.47 36.37,18.47 35.86,18.97 35.86,20.8 35.7,20.97 31.63,20.97 30.35,22.25 24.76,22.25 24.26,21.74 24.26,16.55 24.65,16.15 28.7,16.15
DGND on BOTTOM: 124.24,36.72 124.24,42.08 124.43,42.27 125.58,42.27 126.09,42.78 127.61,42.78 127.76,42.93 127.76,43.67 127.64,43.79 123.16,43.79 122.91,43.54 122.91,39.6 122.2,38.9 116.29,38.9 116.15,38.76 116.15,36.75 116.58,36.32 123.85,36.32
DGND on BOTTOM: 81.74,43.82 81.74,42.19 81.79,42.14 81.79,40.41 82.19,40.01 82.19,38.67 80.9,37.37 80.9,37.01 80.98,36.93 82.07,36.93 82.19,36.8 82.19,36.22 82.37,36.04 83.26,36.04 83.36,36.14 83.36,37.82 83.19,38 83.19,39.05 82.96,39.27 82.96,41.78 83.79,42.62 83.79,43.64 83.52,43.91 81.83,43.91
DGND on BOTTOM: 83.69,32.56 83.69,31.7 83.79,31.6 84.96,31.6 85.24,31.88 85.24,32.05 85.12,32.18 85.12,32.87 85.04,32.94 84.73,32.94 84.61,32.82 84.61,32.69 84.53,32.61 83.74,32.61
DGND on BOTTOM: 188.11,28.01 188.11,22.38 188.45,22.05 189.92,22.05 190.2,22.33 190.2,25.5 190.8,26.11 191.44,26.11 191.77,26.44 191.77,28.02 191.43,28.36 188.45,28.36
DGND on BOTTOM: 78.55,37.6 78.55,39.87 78.44,39.98 73.13,39.98 72.85,39.7 72.85,37.63 72.92,37.56 73.46,37.56 73.71,37.3 75.01,37.3 75.31,37.61 77.72,37.61 77.88,37.45 77.88,35.1 78,34.98 78.23,34.98 78.36,35.1 78.36,37.41
DGND on BOTTOM: 194.56,8.13 1.02,8.13 1.02,64.52 194.56,64.52 ; 96 cut-outs
DGND on BOTTOM: 89.08,28.98 89.49,28.57 90.74,28.57 90.86,28.45 90.86,28.07 90.7,27.91 87.05,27.91 86.9,28.06 86.9,28.85 87.03,28.98
DGND on BOTTOM: 73.63,34.07 75.9,34.07 76.02,34.19 76.02,34.63 75.82,34.83 73.62,34.83 73.56,34.77 73.56,34.14
DGND on BOTTOM: 86.41,24.89 86.32,24.97 86.32,26.23 86.58,26.49 87.99,26.49 88.14,26.34 88.14,25.03 87.99,24.89
DGND on BOTTOM: 7.32,18.03 10.72,18.03 10.98,18.29 10.98,19.82 10.76,20.04 7.34,20.04 7.04,19.74 7.04,18.31
DGND on BOTTOM: 127.95,36.45 129.41,36.45 129.67,36.7 129.67,40.45 129.48,40.64 127.66,40.64 127.52,40.5 127.52,39.92 127.15,39.55 127.15,39.16 127.75,38.57 127.75,36.64
DGND on BOTTOM: 118.16,53.44 125.43,53.44 125.68,53.19 125.68,50.57 125.43,50.32 123.49,50.32 122.83,49.66 118.16,49.66 117.91,49.91 117.91,53.19
DGND on BOTTOM: 81.98,26.71 83.24,26.71 83.27,26.67 83.27,23.14 83.64,22.77 83.64,22.45 83.49,22.3 81.89,22.3 81.79,22.4 81.79,26.52
DGND on BOTTOM: 86.33,34.34 89.03,34.34 89.23,34.14 89.63,34.14 89.74,34.03 89.74,33.57 89.73,33.56 89.73,32.96 89.48,32.72 88.75,32.72 88.44,33.02 88.44,33.32 88.29,33.48 86.64,33.48 86.31,33.15 86.26,33.15 85.78,33.63 85.78,33.78
DGND on BOTTOM: 11.39,33.44 12.43,33.44 12.84,33.03 12.84,30.99 12.97,30.86 14.61,30.86 14.78,31.03 14.78,31.4 14.66,31.53 13.5,31.53 13.39,31.65 13.39,33.99 13.21,34.16 11.44,34.16 11.24,33.97 11.24,33.59
DGND on BOTTOM: 37.67,38.28 37.92,38.02 37.92,37.39 37.67,37.13 35.76,37.13 35.66,37.24 35.66,38.2 35.74,38.28
DGND on BOTTOM: 188.11,49.86 188.11,44.23 188.45,43.89 189.92,43.89 190.2,44.17 190.2,47.35 190.8,47.96 191.44,47.96 191.77,48.29 191.77,49.92 191.49,50.2 188.45,50.2
DGND on L02_GND1: 6.16,19.04 4.93,19.04 4.37,19.61 4.37,22.07 4.95,22.66 6.08,22.66 7.16,23.74 7.16,25.7 6.91,25.96 1.36,25.96 1.11,26.21 1.11,64.53 194.69,64.53 194.69,57.71 194.18,57.2 191.57,57.2 191.06,56.69 191.06,50.85 191.82,50.09 191.82,40.94 190.8,39.93 190.8,29.01 191.82,27.99 191.82,18.85 191.06,18.08 191.06,16.05 191.82,15.29 194.11,15.29 194.69,14.71 194.69,8.11 10.06,8.11 8.84,9.33 8.84,16.37 ; 3 cut-outs
DGND on L05_GND2: 27.8,8.11 27.48,8.43 27.48,15.54 27.23,15.8 24.43,15.8 23.63,16.6 22.19,16.6 20.75,15.16 15.67,15.16 15.39,15.45 15.39,15.95 15.04,16.31 8.9,16.31 6.74,18.47 5.68,18.47 4.11,20.03 4.11,22.4 4.37,22.66 6.65,22.66 7.16,23.16 7.16,25.7 6.91,25.96 1.36,25.96 1.15,26.17 1.15,63.32 2.23,64.4 193.75,64.4 193.77,64.37 193.79,64.35 194.17,64.02 194.5,63.64 194.62,63.6 194.69,63.7 194.69,57.71 194.18,57.2 191.57,57.2 191.06,56.69 191.06,50.85 191.82,50.09 191.82,40.94 190.8,39.93 190.8,29.01 191.82,27.99 191.82,18.85 191.06,18.08 191.06,16.05 191.82,15.29 194.11,15.29 194.69,14.71 194.69,8.11 ; 3 cut-outs
VBUS_TYPEC on TOP: 19.64,18.49 19.32,18.81 19.32,19.79 19.11,19.99 17.66,19.99 17.27,19.61 17.27,18.68 17.19,18.6 15.31,18.6 15.11,18.8 15.11,21.34 15.11,21.34 15.11,25.87 15.58,26.33 21.03,26.33 21.63,25.73 21.63,22.2 21.48,22.05 21.48,20.8 20.99,20.31 20.99,19.18 20.3,18.49
VBUS_TYPEC on BOTTOM: 17.31,20.45 17.31,19.57 17.7,19.18 19.3,19.18 19.42,19.3 19.42,24.1 19.71,24.38 20.9,24.38 22.66,22.63 22.66,17.71 21.06,16.11 15.39,16.11 14.1,17.4 14.1,20.32 14.48,20.7 17.05,20.7
VBUS_TYPEC on L03_SIG1: 15.11,21.96 15.12,21.97 15.12,24.81 16.63,26.33 21.44,26.33 21.83,25.94 21.83,18.89 21.43,18.5 20.3,18.5 20.3,18.49 15.46,18.49 15.11,18.85
VBUS_XDS_USB on TOP: 4.8,22.78 4.8,22.25 4.93,22.12 6.55,22.12 7.51,23.09 10.18,23.09 10.36,23.27 10.36,24.08 10.08,24.36 7.09,24.36 6.39,23.66 5.68,23.66
VBUS_XDS_USB on BOTTOM: 12.21,32.36 12.21,32.77 12.09,32.89 11.4,32.89 11.3,32.79 10.54,32.79 10.44,32.89 10.44,34.09 10.31,34.21 9.04,34.21 8.91,34.08 8.91,32.28 8.89,32.26 8.89,30.44 10.57,28.77 10.57,25.68 9.17,24.28 7.62,24.28 7.37,24.03 7.37,23.21 7.55,23.03 9.95,23.03 11.95,25.03 11.95,29.12 9.7,31.37 9.7,31.81 9.99,32.11 11.12,32.11 11.38,32.36
VCC3V3_TA on TOP: 25.98,52.07 25.98,42.44 26.19,42.24 26.59,42.24 26.72,42.37 26.72,52.14 26.7,52.16 26.07,52.16
VCC3V3_TA on TOP: 5.34,42.29 5.34,42.78 5.84,43.28 5.84,43.9 5.63,44.12 4.01,44.12 3.53,43.64 3.53,41.79 3.72,41.61 5.13,41.61 5.49,41.25 8.05,41.25 8.26,41.45 8.26,41.78 8.05,41.99 5.65,41.99
VCC3V3_TA on TOP: 29.69,54.19 29.69,52.76 29.16,52.22 28.4,52.22 28.19,52.02 28.19,51.38 28.27,51.31 29.83,51.31 30.14,51.61 30.1,51.61 30.46,51.97 30.46,52.1 30.56,52.2 30.56,52.91 31.32,53.68 31.32,54.16 31.16,54.32 29.82,54.32
VCC3V3_TA on TOP: 10.03,55.4 11.25,55.4 11.51,55.14 11.51,47.17 11.25,46.91 10.03,46.91 9.78,47.17 9.78,55.14
VCC3V3_TA on BOTTOM: 11.68,55.21 11.68,48.06 11.73,48.01 12.4,48.01 12.71,48.32 12.71,54.91 12.36,55.26 11.73,55.26
VCC3V3_TA on BOTTOM: 7.24,25.78 7,26.03 7,27.7 6.38,28.32 6.38,30.1 6.17,30.31 6.17,33.91 5.31,34.77 5.31,35.89 5.56,36.14 7.98,36.14 8.13,35.99 8.13,33.81 8.13,30.98 7.29,30.14 7.29,28.75 7.95,28.09 9.44,28.09 9.87,27.66 9.87,25.85 9.8,25.78
VCC3V3_TA on BOTTOM: 22.23,54.48 22.23,53.16 22.38,53.01 22.96,53.01 23.06,53.11 23.06,53.9 23.35,54.19 24.69,54.19 24.73,54.23 24.73,54.79 24.69,54.83 23.08,54.83 22.83,54.58 22.33,54.58
VCC3V3_TA on L03_SIG1: 3.05,45.09 3.05,33.73 4.09,32.69 6.71,32.69 7.72,33.71 7.72,35.46 6.02,37.16 6.02,43.99 7.19,45.16 7.57,44.78 15.6,44.78 17.46,46.63 25.49,46.63 27.15,48.29 29.4,48.29 30.35,49.25 30.35,53.31 28.52,55.14 23.79,55.14 20.6,51.95 13.07,51.95 12.4,52.63 12.4,55.32 11.89,55.83 10.68,55.83 6.83,51.98 6.83,48.87 ; 3 cut-outs
VCC3V3_XDS on TOP: 18.08,37.87 17.5,38.46 17.5,46.47 18.04,47.01 24.03,47.01 24.03,46.43 24.26,46.43 24.67,46.02 24.81,46.02 24.81,46.44 26.05,46.44 26.05,46.7 24.81,46.7 24.81,47.01 37.75,47.01 38.35,46.4 38.35,38.13 38.1,37.87 ; 4 cut-outs
VCC3V3_XDS on TOP: 14.17,34.67 14.17,31.45 15.65,29.98 15.65,28.02 15.7,27.96 23.3,27.96 24.12,27.14 29.02,27.14 29.71,26.45 33.25,26.45 35.64,28.83 38.53,28.83 39.5,29.79 39.5,34.82 37.97,36.35 22.11,36.35 20.43,34.67 ; 3 cut-outs
VCC3V3_XDS on BOTTOM: 35.8,40.44 36.73,40.44 36.91,40.26 36.91,39.19 36.65,38.94 35.78,38.94 35.66,39.06 35.66,40.3
VCC3V3_XDS on BOTTOM: 36.5,30.39 36.34,30.23 35.86,30.23 35.53,30.55 35.53,32.84 35.71,33.02 36.32,33.02 36.5,32.84
VCC3V3_XDS on BOTTOM: 25.16,26.92 26.22,26.92 26.42,26.72 26.42,26.16 26.16,25.91 25.18,25.91 25.04,26.05 25.04,26.79
VCC3V3_XDS on BOTTOM: 14.02,32.48 14.66,32.48 15.01,32.13 16.51,32.13 16.6,32.04 17.24,32.04 17.36,32.17 17.36,32.7 17.27,32.8 16.22,32.8 16.13,32.89 16.13,34.68 16.01,34.8 14.1,34.8 13.9,34.6 13.9,32.59
VCC3V3_XDS on L03_SIG1: 13.64,33.98 13.64,29.13 15.19,27.58 20.42,27.58 20.83,27.99 22.66,27.99 23.62,27.03 23.62,22.3 26.34,19.58 35.99,19.58 36.49,19.08 39.1,19.08 40.17,20.15 59.02,20.15 59.34,20.48 59.34,24.27 58.96,24.65 38.57,24.65 38.38,24.84 38.38,32.72 38.23,32.87 38.23,39.29 36.93,40.59 34.06,40.59 33.13,39.66 24.17,39.66 21.39,36.88 16.54,36.88 ; 1 cut-out
VDD_1V1 on BOTTOM: 124.71,30.43 124.71,25.98 124.97,25.73 126.53,25.73 126.78,25.98 126.78,27.91 126.51,28.18 126.51,28.98 126.87,29.35 126.87,29.83 126.76,29.95 126.09,29.95 125.6,30.43
VDD_1V1 on L04_PWR1: 136.5,23.51 136.93,23.08 139.03,23.08 139.51,23.56 139.51,27.29 139.9,27.69 144.76,27.69 145.1,28.03 145.1,32.19 144.53,32.77 139.36,32.77 138.64,33.49 138.64,36.05 141.78,39.19 141.78,41.82 142.43,42.46 144.39,42.46 145.1,43.17 145.1,47.86 144.31,48.65 133.76,48.65 133.06,47.95 133.06,47 136.83,43.23 136.83,40.24 132.62,36.04 125.6,36.04 124.87,35.31 124.87,25.66 125.21,25.32 130.57,25.32 131.39,26.15 131.39,28.03 131.94,28.58 135.8,28.58 136.5,27.87
VDD_1V8 on TOP: 66.55,50.44 66.27,50.16 65.19,50.16 65.18,50.17 64.2,50.17 63.93,50.44 63.93,51.59 63.63,51.89 63.12,51.89 62.76,52.25 62.76,53.65 62.96,53.85 66.32,53.85 66.55,53.62
VDD_1V8 on BOTTOM: 68.12,31.8 69.52,31.8 69.77,31.55 69.77,25.2 69.45,24.87 68.82,24.87 68.34,25.34 68.34,30.51 67.87,30.99 67.87,31.55
VDD_1V8 on BOTTOM: 91.87,33.27 93.57,33.27 93.83,33.02 93.83,28.04 93.52,27.74 91.62,27.74 91.37,27.99 91.37,30.83 91.74,31.19 91.74,33.14
VDD_1V8 on BOTTOM: 64.49,52.81 64.49,51.14 68.24,47.39 71.29,47.39 74.65,44.02 74.65,40.89 74.92,40.62 78.49,40.62 78.49,42.62 78.23,42.88 78.23,43.77 68.85,53.16 64.83,53.16
VDD_1V8 on L04_PWR1: 91.36,27.25 91.36,30.76 87.73,34.39 87.73,38.15 86.18,39.7 86.18,39.88 86.11,39.95 83.91,39.95 82.08,38.13 79.32,38.13 76.69,40.76 76.69,42.3 77.18,42.79 78.07,42.79 78.28,42.58 78.28,41.48 80.44,39.32 81.46,39.32 83.24,41.1 89.83,41.1 90.84,40.1 90.84,35.78 93.62,32.99 93.62,24.21 93.24,23.83 90.15,23.83 87.99,21.66 87.99,20.19 87.38,19.58 70.38,19.58 67.21,22.76 67.21,25.85 69.88,25.85 70.15,25.58 70.15,24.77 73.53,21.39 85.7,21.39 87.48,23.16 87.48,23.37
VDD_1V8_R on TOP: 61.83,48.01 61.96,47.88 66.37,47.88 66.56,48.07 66.56,49.65 66.43,49.78 63.65,49.78 63.41,49.54 63.41,49.24 62.59,48.41 61.85,48.41 61.83,48.39
VDD_2V5 on BOTTOM: 124.71,36.7 124.71,41.15 125.6,41.15 126.09,40.66 126.76,40.66 126.87,40.55 126.87,40.17 126.51,39.81 126.51,38.9 126.78,38.63 126.78,36.53 126.57,36.32 125.09,36.32
VDD_2V5 on BOTTOM: 143.81,28.19 145.11,28.19 145.36,27.94 145.36,25.35 145.11,25.1 143.81,25.1 143.56,25.35 143.56,27.94
VDD_2V5 on BOTTOM: 143.87,47.14 145.14,47.14 145.39,46.89 145.39,44.02 145.14,43.76 143.87,43.76 143.61,44.02 143.61,46.89
VDD_2V5 on L03_SIG1: 144.17,50.14 147.5,50.14 148.13,49.5 148.13,25.45 147.5,24.81 144.19,24.81 143.37,25.64 143.37,34.06 142.26,35.17 125.27,35.17 124.84,35.6 124.84,38.63 124.99,38.78 141.39,38.78 143.69,41.07 143.69,49.66
VDD_CORE_0V85 on TOP: 60.41,35.18 54.97,35.18 54.77,34.98 54.77,31.06 54.85,30.99 55.62,30.99 55.94,31.31 55.94,31.45 56.17,31.67 60.32,31.67 60.57,31.92 60.57,35.02
VDD_CORE_0V85 on BOTTOM: 79.12,26.42 80.78,26.42 80.95,26.25 80.95,22.83 81.15,22.63 81.15,22.41 81.01,22.27 79.14,22.27 78.96,22.44 78.96,26.26
VDD_CORE_0V85 on BOTTOM: 77.5,35.52 73.57,35.52 73.47,35.62 73.47,36.62 73.62,36.77 74.97,36.77 75.11,36.63 77.57,36.63 77.6,36.61 77.6,35.61
VDD_CORE_0V85 on L04_PWR1: 84.2,36.15 83.5,36.86 54.89,36.86 54.23,36.2 54.23,26.74 70.32,26.74 74.41,22.64 78.68,22.64 78.82,22.5 78.82,22.01 81.57,22.01 84.2,24.64
VDD_CORE_0V85_R on TOP: 51.54,34.92 51.8,35.18 53.98,35.18 54.25,34.91 54.25,32.13 54.15,32.04 54.15,31.25 54.1,31.2 53,31.2 52.94,31.26 52.94,32.13 52.68,32.38 51.67,32.38 51.54,32.51
VDD_CORE_0V85_SW on TOP: 50.85,35.05 49.64,35.05 49.51,34.92 49.51,32.44 49.69,32.26 50.86,32.26 51,32.4 51,34.9
VDDA_1P8_USB0 on BOTTOM: 86.58,32.41 86.58,31.88 86.65,31.8 88.33,31.8 88.58,31.55 90.87,31.55 91.03,31.71 91.03,32.98 90.95,33.06 90.12,33.06 89.99,32.92 89.99,32.37 89.83,32.22 88.42,32.22 88.15,32.49 86.66,32.49
VDDA_1V8 on BOTTOM: 79.24,41.72 79.24,40.03 79.04,39.82 79.04,38 79.3,37.74 80.21,37.74 80.42,37.95 80.42,39.56 80.91,40.06 80.91,41.68 80.68,41.91 79.43,41.91
VDDA_PLL0 on BOTTOM: 90.72,30.67 90.72,29.22 90.57,29.07 89.83,29.07 89.3,29.6 87.27,29.6 87.16,29.72 87.16,30.1 87.26,30.2 88.25,30.2 88.82,30.77 90.62,30.77
VDDA_PLL1 on BOTTOM: 70.43,27.1 70.43,25.48 70.56,25.35 71.65,25.35 71.83,25.53 71.83,25.83 72.03,26.03 75.06,26.03 75.45,26.43 75.45,27.52 75.26,27.71 74.7,27.71 74.55,27.56 74.55,27.3 74.22,26.97 72.19,26.97 71.88,27.28 70.61,27.28
VDDA_PLL2 on BOTTOM: 70.36,31.62 70.36,30.34 70.48,30.21 71.95,30.21 72.52,30.78 73.13,30.78 73.23,30.89 73.23,31.55 73.03,31.75 70.48,31.75
VDDA_TEMP on BOTTOM: 70.48,29.06 70.48,27.99 70.66,27.81 71.81,27.81 72.47,28.47 73.18,28.47 73.3,28.6 73.3,29.06 72.82,29.54 70.97,29.54
VDDSHV_3V3 on BOTTOM: 83.31,29.01 83.31,27.84 84.35,27.84 84.35,29.01
VDDSHV_3V3 on BOTTOM: 73.62,32.82 74.7,32.82 74.96,33.07 77.42,33.07 77.57,32.92 77.57,32.03 77.1,31.56 75.18,31.56 74.93,31.3 74.93,30.66 75.08,30.51 77.95,30.51 78.64,29.82 78.64,29.16 78.56,29.08 78.28,29.08 78.05,29.31 78.05,29.51 77.9,29.67 77.22,29.67 76.81,29.26 76.81,26.67 76.68,26.54 76.08,26.54 75.98,26.64 75.98,27.8 74.26,29.52 74.26,31.12 73.53,31.85 73.53,32.73
VDDSHV_3V3 on BOTTOM: 83.74,39.28 84.67,39.28 84.84,39.12 84.84,35.69 84.58,35.43 83.74,35.43 83.67,35.51 83.67,39.2
VDDSHV_3V3 on BOTTOM: 84.25,26.46 85.68,26.46 85.89,26.24 85.89,24.47 85.85,24.51 85.85,22.34 85.61,22.1 84.58,22.1 84.12,22.56 84.12,26.32
VDDSHV_3V3 on L04_PWR1: 85.08,27.34 84.71,26.97 84.71,24.35 83.73,23.37 83.73,22.68 84.4,22.01 85.69,22.01 87.02,23.34 87.02,23.6 90.5,27.08 90.5,31.29 87.19,34.6 87.19,38.15 86.09,39.25 84.11,39.25 83.59,38.73 83.59,37.4 83.67,37.32 83.68,37.32 84.41,36.6 84.41,34.15 84.1,33.84 84.1,29.69 85.08,28.71
(no net) on TOP: 194.56,8.13 1.56,8.13 1.56,64.52 194.56,64.52 ; 113 cut-outs
(no net) on L03_SIG1: 194.6,62.8 194.6,57.63 194.18,57.2 191.57,57.2 191.06,56.69 191.06,50.85 191.82,50.09 191.82,40.94 190.8,39.93 190.8,29.01 191.82,27.99 191.82,18.85 191.06,18.08 191.06,16.05 191.82,15.29 194.11,15.29 194.61,14.78 194.61,9.7 193.09,8.18 27.74,8.18 11.07,8.11 9.09,10.08 9.09,17.32 6.62,19.79 6.62,23.2 7.16,23.74 7.16,25.7 6.91,25.96 1.36,25.96 1.2,26.12 1.2,63.41 2.25,64.47 192.94,64.47 ; 118 cut-outs
BP_3V3 on TOP (solid shape): 104.26,13.46 103.31,12.73 102.62,13.42 102.6,13.46 102.62,13.51 103.31,14.19
EQEP1_A on TOP (solid shape): 157.41,11.62 157.46,11.64 157.5,11.62 158.19,10.93 157.46,10.02 156.73,10.93
EQEP2_A on BOTTOM (solid shape): 157.41,17.97 157.46,17.99 157.5,17.97 158.19,17.28 157.46,16.37 156.73,17.28
ETH1_EARTH on TOP, BOTTOM: 191.47,34.39 191.47,29.24 192.46,28.24 192.46,18.66 191.47,17.67 191.47,16.02 191.81,15.67 194.42,15.67 194.69,15.94 194.69,34.45 194.34,34.79 191.87,34.79
ETH2_EARTH on TOP, BOTTOM: 191.47,56.24 191.47,51.18 192.46,50.19 192.46,40.51 191.47,39.52 191.47,37.87 191.84,37.49 194.39,37.49 194.69,37.79 194.69,56.22 194.26,56.64 191.87,56.64
USBC_SHIELD on TOP, L05_GND2: 13.11,8.83 12.81,9.13 12.81,15.88 13.06,16.13 14.97,16.13 15.35,15.75 15.35,14.73 15.73,14.35 21.32,14.35 21.82,14.86 21.82,15.88 22.08,16.13 23.98,16.13 24.24,16.38 24.24,16.83 24.42,17.02 27.03,17.02 27.28,16.76 27.28,9.15 26.96,8.83
USBC_SHIELD on BOTTOM: 13.1,8.83 12.81,9.13 12.81,15.88 13.06,16.13 14.97,16.13 15.35,15.75 15.35,14.73 15.73,14.35 21.32,14.35 21.82,14.86 21.82,15.88 22.08,16.13 23.6,16.13 24.08,15.65 24.08,14.45 24.54,14 27.42,14 27.7,13.72 27.7,9.3 27.24,8.83
USBC_SHIELD on L02_GND1: 13.49,9.72 12.81,10.41 12.81,15.88 13.06,16.13 13.86,16.13 14.77,15.22 14.77,14.47 15.11,14.12 21.51,14.12 22.15,14.76 22.15,15.77 22.5,16.13 23.98,16.13 24.24,16.38 24.24,16.83 24.42,17.02 27.03,17.02 27.28,16.76 27.28,10.43 26.57,9.72
USBC_SHIELD on L03_SIG1: 13.55,9.66 12.81,10.4 12.81,15.88 13.06,16.13 14.97,16.13 15.35,15.75 15.35,14.73 15.73,14.35 21.32,14.35 21.82,14.86 21.82,15.88 22.08,16.13 23.98,16.13 24.24,16.38 24.24,16.83 24.42,17.02 27.03,17.02 27.28,16.76 27.28,10.43 26.52,9.66
USBC_SHIELD on L04_PWR1: 13.11,8.83 12.81,9.13 12.81,15.88 13.06,16.13 14.97,16.13 15.35,15.75 15.35,14.73 15.73,14.35 21.32,14.35 21.82,14.86 21.82,15.88 22.08,16.13 23.98,16.13 23.99,16.14 26.61,16.14 27.14,15.61 27.14,9.01 26.96,8.83
VPP_1V8 on TOP: 53.24,39.77 53.24,38.68 53.44,38.48 54.84,38.48 55.12,38.76 56.62,38.76 56.72,38.86 56.72,40.36 56.44,40.64 55.32,40.64 54.61,39.93 53.39,39.93
VSYS_3V3 on TOP: 56.32,45.11 54.44,46.99 50.55,46.99 50.27,46.71 50.27,46.42 50.08,46.23 49.27,46.23 49.2,46.3 49.2,50.47 49.87,51.14 54.95,51.14 57.71,48.39 60.04,48.39 60.18,48.25 60.18,47.88 60.05,47.75 59.56,47.75 59.44,47.62 59.44,45.38 59.16,45.11
VSYS_3V3 on TOP: 95.96,60.53 100.61,60.53 100.86,60.27 100.86,58.22 100.68,58.03 98.56,58.03 98.42,58.17 96.01,58.17 95.71,58.47 95.71,60.27
VSYS_3V3 on TOP: 31.7,53.03 31.7,51.74 31.75,51.69 32.26,51.69 32.44,51.51 34.85,51.51 35.08,51.74 35.08,53.31 34.93,53.45 32.12,53.45
VSYS_3V3 on TOP: 139.57,36.68 140.18,36.68 140.39,36.48 140.39,33.7 140.25,33.57 139.51,33.57 139.32,33.76 139.32,36.42
VSYS_3V3 on TOP: 8.81,44.17 8.81,43.43 9.35,42.9 9.35,41.76 9.49,41.61 10.65,41.61 10.82,41.78 10.82,43.89 10.54,44.17
VSYS_3V3 on TOP: 139.57,55.73 140.18,55.73 140.39,55.53 140.39,52.75 140.25,52.62 139.62,52.62 139.32,52.92 139.32,55.47
VSYS_3V3 on BOTTOM: 122.42,29.54 122.42,31.47 122.32,31.57 121.38,31.57 120.97,31.99 116.42,31.99 116.15,31.72 116.15,29.11 116.36,28.91 121.79,28.91
VSYS_3V3 on BOTTOM: 35.69,15.65 37.31,15.65 37.57,15.39 37.57,12.14 37.31,11.89 35.69,11.89 35.43,12.14 35.43,15.39
VSYS_3V3 on BOTTOM: 124.16,46.15 126.77,46.15 127.03,45.9 127.03,44.48 126.77,44.22 124.16,44.22 123.9,44.48 123.9,45.9
VSYS_3V3 on BOTTOM: 90.07,23.64 90.07,21.25 87.07,21.25 86.52,21.8 86.52,24.15 86.61,24.24 89.47,24.24
VSYS_3V3 on BOTTOM: 122.42,40.25 122.42,43.48 122.2,43.7 120.79,43.7 119.79,42.71 116.33,42.71 116.13,42.5 116.13,39.85 116.36,39.62 121.79,39.62
VSYS_3V3 on L04_PWR1: outline of 89 points within 1.11,8.13 194.67,64.52 ; 3 cut-outs
VSYS_3V3_R on TOP: 45.94,50.28 46.08,50.42 48.38,50.42 48.6,50.2 48.6,46.51 48.41,46.32 47.26,46.32 47.14,46.44 47.14,47.2 46.71,47.62 46.07,47.62 45.94,47.75
VSYS_3V3_SW on TOP: 45.14,50.29 43.92,50.29 43.79,50.16 43.79,47.68 43.98,47.5 45.15,47.5 45.29,47.64 45.29,50.14
VSYS_5V0 on TOP: 120.83,44.32 120.83,42.11 120.93,42.01 121.56,42.01 121.84,42.29 124.19,42.29 125.46,41.03 125.46,22.4 127.38,20.47 130.22,20.47 135.92,14.78 135.92,12.7 136.47,12.14 138.56,12.14 138.73,12.32 138.73,14.48 129.55,23.66 129.55,43.38 128.43,44.5 121.01,44.5
VSYS_5V0 on TOP: 32.62,26.06 31.67,25.12 31.67,23.19 31.86,23.01 32.81,23.01 32.91,23.1 33.25,22.76 35.33,22.76 36.6,21.49 38.66,21.49 39.14,21.97 39.14,25.67 38.74,26.06
VSYS_5V0 on TOP: 45.34,29.21 44.96,29.59 44.96,35.28 46.35,36.68 46.35,39.52 46.71,39.88 51.63,39.88 51.85,39.66 51.85,38.65 51.73,38.53 48.65,38.53 48.08,37.96 48.08,34.29 48.86,33.51 48.86,32.68 49.76,31.78 49.76,29.47 49.41,29.47 49.15,29.21
VSYS_5V0 on TOP: 44.05,44.94 44.05,47.02 43.16,47.91 43.16,48.8 42.76,49.2 39.76,49.2 39.36,48.81 39.36,44.71 39.5,44.58 43.69,44.58
VSYS_5V0 on L04_PWR1: 41.96,15.06 37.44,15.06 36.08,16.42 36.08,18.82 32.01,22.9 32.01,39.73 27.4,44.35 25.4,44.35 20.8,48.95 12.42,48.95 11.58,49.79 11.58,57.1 11.96,57.48 23.88,57.48 29.68,51.69 41.64,51.69 44.94,48.39 44.94,45.97 49.25,41.66 51.16,41.66 52.68,40.13 52.68,23.7 65.53,23.7 70.15,19.08 88.04,19.08 88.19,18.92 149.42,18.92 153.25,22.76 160.1,22.76 161.72,24.38 164.87,24.38 165.56,23.7 165.56,16.87 167.09,15.34 168.91,15.34 170.36,13.9 170.36,8.84 169.77,8.26 73.32,8.26 67.16,14.41 42.61,14.41
VUSB_5V0 on TOP: 22.23,22.78 22.23,26.29 22.45,26.52 29.21,26.52 29.98,25.74 29.98,24.18 30.28,23.89 30.28,23.06 30.1,22.89 29.06,22.89 28.82,22.64 27.88,22.64 27.43,22.2 22.81,22.2
VUSB_5V0 on BOTTOM: 1.4,27.77 1.4,26.61 1.69,26.31 5.99,26.31 6.21,26.54 6.21,27.8 6.1,27.91 4.68,27.91 4.53,27.76 3.11,27.76 2.86,28.02 1.64,28.02
XDS_SHIELD on TOP, L04_PWR1, L05_GND2: 1.78,14.55 1.11,15.22 1.11,25.85 1.35,26.09 6.65,26.09 6.96,25.78 6.96,24.71 6.27,24.03 4.01,24.03 3.56,23.58 3.56,18.71 4.15,18.11 6.55,18.11 7.67,16.99 10.64,16.99 10.95,16.69 10.95,14.92 10.58,14.55
XDS_SHIELD on BOTTOM: 1.58,14.33 1.11,14.8 1.11,25.34 1.42,25.65 6.42,25.65 6.83,25.25 6.83,23.64 6.09,22.91 4.26,22.91 3.78,22.44 3.78,18.54 4.29,18.03 6.27,18.03 7.14,17.16 7.14,16.61 8.03,15.72 11.02,15.72 11.2,15.54 11.2,14.54 10.99,14.33
XDS_SHIELD on L02_GND1: 1.78,14.55 1.11,15.22 1.11,25.85 1.35,26.09 6.65,26.09 6.96,25.78 6.96,24.71 6.27,24.03 4.01,24.03 3.56,23.58 3.56,18.71 4.15,18.11 6.55,18.11 8.15,16.51 8.15,14.94 7.77,14.55
XDS_SHIELD on L03_SIG1: 1.78,14.55 1.11,15.22 1.11,25.85 1.35,26.09 6.65,26.09 6.96,25.78 6.96,24.71 6.27,24.03 4.01,24.03 3.56,23.58 3.56,18.71 4.15,18.11 6.55,18.11 7.67,16.99 8.23,16.99 8.43,16.79 8.43,14.88 8.1,14.55
N30372794 on BOTTOM (solid shape): 175.96,30.39 175.98,30.35 175.96,30.3 175.28,29.62 174.46,30.35 175.28,31.08
N30391632 on BOTTOM (solid shape): 175.96,52.24 175.98,52.2 175.96,52.15 175.28,51.47 174.46,52.2 175.28,52.93

Small or netless copper shapes (teardrops, artwork): 585 on TOP, 538 on BOTTOM, 379 on L03_SIG1, 5 on L04_PWR1, 2 on L05_GND2

## Text on the board
Ref Des/Silkscreen Bottom: B | A | C | J1 | J3 | J4 | J2 | J5 | J8 | J7 | J6 | LP-AM243 | Development Kit | www.ti.com/launchpad | TEST AUTOMATION | FOR EVALUATION ONLY; | NOT FCC APPROVED FOR RESALE
User.Comments: BOARD NAME: | AM243x LP EVM | REV: | DATE: 04/05/2021 | E2 | DESCRIPTION: | SHEET    OF 13 | TI PART NO | SCALE: 1 | TEXAS INSTRUMENTS
Ref Des/Silkscreen Top: XDS110,MAIN UART0 | A | USR LED2 | MCU PORZ | BOOT MODE SEL | VBUS_TYPEC | MCU RESETZ | BRD PWR IN | VSYS_5V0 ON | VSYS_3V3 ON | VDDCORE_0V85 ON | VCC3V3_XDS | SOC_RESET_REQZ | VSYS_5V0 | VSYS_3V3 | MCU_RESETz | USER_INTn | VDD_1V8 | J1 | J3 | J4 | J2 | USER INTN | SOC_RESETSTATz | PORz_OUT | FSI | VDD_2V5 | VDD_1V1 | J8 | J6 | J5 | J7 | eQEP1 | MAIN UART1 | MCU UART0 | eQEP2 | IND LED GREEN | MCAN0 | IND LED RED | IND LEDS | IND LED BCLR | USR LED1 | PWR ERR | MCU_PORz | 21 | 1 | 20 | 40 | 5V0 | 3V3 | GND | 2 | 39 | 19 | 3 | 18 | 38 | 23 | 4 | 17 | 37 | 24 | 5 | 16 | 36 | 25 | 6 | 15 | 35 | 26 | 7 | 14 | 34 | 27 | 8 | 13 | 33 | 28 | VDD_CORE_0V85 | 9 | 32 | 12 | 29 | SoC_RESET_REQz | 11 | 30 | 10 | 31 | OSPI0 CLK | MCU_SAFTY_ERRz | MCU RESETSTATz | 60 | 80 | 61 | 41 | 42 | 79 | 59 | 43 | 78 | 58 | 63 | 44 | 77 | 57 | 64 | 45 | 76 | 56 | 65 | 46 | 75 | 55 | 66 | 47 | 74 | 54 | 67 | 48 | 73 | 53 | 68 | 49 | 72 | 52 | 69 | 51 | 50 | 70 | 71 | PRG/CPSW RGMII2 | PRG/CPSW RGMII1 | SL# | ASSY | OPN#: LP-AM243 | PCB#: PROC109E2
PAGE_OUTLINE: REVIEWED BY | APPROVED BY | LAYOUT BY | SIGNATURES | PA | ZA | AMB | 04-05-21 | DATE | SIZE | SCALE: | D | NONE | SHEET 1 OF 13 | TI PART NO | Rev | TEXAS INSTRUMENTS | E2 | AM243x LP EVM | PROC109
DIMENSION: FOR DETAILED STACK-UP, PROC109_STACK_UP.pdf SHALL BE REFERRED | DETAIL-A
User.10: R178 | R186 | R189 | R197 | R209 | R171 | C146 | C155 | R182 | R187 | Q8 | Y1 | R196 | R202 | R212 | R219 | R222 | R231 | C114 | R246 | D7 | U27 | C120 | C132 | D6 | R176 | R195 | C85 | D8 | R256 | Q7 | R191 | R170 | C240 | C268 | C129 | C151 | C180 | C191 | C192 | C184 | C135 | C144 | C163 | J2 | J1 | C134 | C141 | C203 | C133 | C140 | C145 | Q16 | R255 | R262 | C260 | C232 | U42 | C161 | FB6 | FB8 | R234 | FB9 | FB3 | R240 | R244 | C193 | C259 | R271 | C94 | C194 | FB2 | C234 | C244 | C250 | C255 | C227 | C126 | C239 | C247 | C251 | C254 | R183 | C116 | C235 | C245 | C249 | C253 | R208 | C237 | C246 | R261 | C206 | FB4 | R206 | FB7 | FB5 | U30 | C209 | C166 | R250 | J6 | J5 | U33 | U39 | R248 | R233 | U29 | C125 | C130 | C222 | R218 | R221 | R230 | R254 | R260 | C98 | C97 | C228 | C93 | C207 | C221 | R242 | C258 | R266 | C86 | C100 | C217 | C231 | C96 | C84 | C159 | C152 | U46 | C119 | R236 | C92 | C95 | C99 | R225 | C197 | C230 | C216 | C107 | C238 | R241 | R245 | R259 | R263 | R276 | Q14 | Q15 | Q10 | Q11 | Q12 | Q13 | R270 | C257 | Q6 | C83 | C261 | C264 | C115 | C127 | Q5 | C195 | C89 | Q4 | Q9 | R200 | R253 | C101 | C252 | U38 | R188 | U26 | U37 | U45 | U28 | U36 | C153 | R287 | C224 | FB1 | U31 | R286 | U40 | C248 | U32 | C87 | U34 | U43 | U35 | U44 | C202 | C160 | C158 | C165 | WHEN ACTUATOR IS OPENED | R251 | J15 | C226 | C243 | C263 | D5 | C79 | C170 | R211 | C131 | R249 | C208 | C91 | C182 | L3 | C154 | C181 | R201 | R175 | R177 | C266 | C242 | C104 | C105 | C102 | C88 | C121 | C262 | C128 | R235 | R224 | C171 | C169 | C189 | C168 | C167 | C210 | C162 | C201 | C214 | C148 | C188 | C200 | C215 | C172 | C147 | C187 | C199 | C175 | C212 | C186 | C173 | C211 | C185 | C150 | C196 | C149 | C213 | C179 | R238 | C108 | R237 | C110 | C117 | C118 | C225 | C241 | C142 | C236 | C136 | R181 | C139 | C138 | R180 | C223 | C137 | R179 | C233 | R239 | R217 | C204 | C156 | R216 | R194 | R207 | R193 | R215 | R192 | R214 | R205 | R213 | R204 | C90 | R203 | R190 | C124 | C220 | C123 | C219 | C122 | C218 | C111 | C183 | C229 | R232 | R247 | R269 | R268 | R229 | R228 | R267 | R184 | C113 | C256 | R185 | C270 | R227 | R275 | R226 | R265 | R264 | C269 | R274 | R281 | R280 | R273 | R257 | R252 | R279 | R272 | C112 | R223 | R220 | R243 | R278 | R277 | R173 | C267 | R210 | R258 | C265 | C164 | R172 | R167 | R166 | R285 | R169 | R284 | R165 | R174 | R283 | R168 | R282 | U41 | C82 | C81 | R199 | C80 | R198 | C190 | C174 | C143 | C198 | C178 | C177 | C176 | C157 | C109 | C103 | C106 | C205 | REV # | SCALE:NONE | SIZE | FILE NAME: | DESCRIPTION | REVISIONS | CCN # | DRAWING NO. | DDMMYY | DATE | OF | REV | AM243x LP EVM ASSEMBLY BOTTOM REV.E1 | SHEET | 02 | C | FY10XXXX5200X0X | *
User.14: LED102 | LED101 | J1 | J5 | J7 | S1 | J3 | C3 | C7 | R1 | C1 | R7 | R5 | Q2 | R2 | Q1 | R3 | R4 | MSP1 | C10 | C8 | TP110 | L1 | C4 | S3 | J4 | JP102 | S2 | J6 | J2 | C11 | C6 | C5 | C12 | C2 | J102 | J8 | C13 | R6 | J101
User.42: 06 | EDGE COUPLED STRIPLINE | EDGE COUPLED MICROSTRIP | L3 | L1,L6 | 4.75 | 5.3 | NA | 50 | L2 | L2,L5
User.44: REV # | SCALE:NONE | SIZE | FILE NAME: | DESCRIPTION | REVISIONS | CCN # | DRAWING NO. | DDMMYY | DATE | OF | REV | SHEET | 02 | C | FY10XXXX5200X0X | *
User.45: FIGURE | SIZE | 8.0 | 16.0 | 36.0 | 40.0 | 44.0 | 46.0 | 62.0 | 32.0 | 124.0 | 126.0 | 48.0x22.0 | 48.0x24.0 | 68.0x34.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 1520 | 14 | 24 | 41 | 80 | 4 | 8 | 92 | 10 | 2 | 01 | 02
