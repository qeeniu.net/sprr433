# Allegro board PROC109E2_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PRG1_RGMII1_RD3: length 25.9
  TOP w0.102: 87.56,27.81 87.23,28.14 86.67,28.14 U18.Y5
  TOP w0.135: 87.56,27.81 89.64,25.73 96.52,25.73 97.23,26.44 106.27,26.44 106.4,26.31 106.4,24.9 106.27,24.77 105.54,24.77 105.32,24.99 v1(105.32,25.84)
  BOTTOM w0.135: U40.23 v1(105.32,25.84)
PRG1_RGMII1_RX_CTL: length 25.9
  TOP w0.102: U18.AA5 87.13,27.86 87.74,27.25
  TOP w0.135: v1(105.21,24.18) 104.04,25.35 100.23,25.35 99.47,26.11 97.66,26.11 96.95,25.4 89.59,25.4 87.74,27.25
  BOTTOM w0.135: U40.21 107.25,23.61 106.63,22.99 104.83,22.99 104.65,23.17 104.65,23.62 v1(105.21,24.18)
PRG1_RGMII1_RXC: length 26.2
  TOP w0.102: 87.74,25.6 87.17,26.16 87.17,26.48 87.01,26.64 86.67,26.64 U18.Y2
  TOP w0.135: v1(103.68,22.28) 102.97,22.99 97.66,22.99 96.49,24.16 89.18,24.16 87.74,25.6
  BOTTOM w0.135: U40.19 108.25,23.62 106.43,21.79 104.17,21.79 v1(103.68,22.28)
PRG1_RGMII1_TD0: length 37.7
  TOP w0.102: v2(84.93,27.91) 84.98,27.86 U18.V5
  L03_SIG1 w0.121: v2(84.93,27.91) 85.19,28.16 88.14,28.16 88.76,27.55 98.57,27.55 v1(98.76,27.37)
  BOTTOM w0.135: v1(98.76,27.37) 99.49,28.1 99.49,29.72 99.36,29.86 98.51,29.86 98.37,29.99 98.37,30.26 98.51,30.4 99.36,30.4 99.49,30.53 99.49,30.8 99.36,30.93 98.51,30.93 98.37,31.07 98.37,31.34 98.51,31.47 99.36,31.47 99.49,31.61 99.49,33.76 103.15,37.41 104.8,37.41 105.84,36.37 106.81,36.37 108.25,34.93 U40.41
PRG1_RGMII1_TD1: length 38
  TOP w0.102: 86.21,25.02 85.61,25.61 85.61,26.08 U18.W2
  TOP w0.135: v1(100.56,22.3) 100.24,22.62 91.73,22.62 90.75,23.6 87.63,23.6 86.64,24.59 86.64,24.59 86.21,25.02
  BOTTOM w0.135: U40.39 107.25,34.56 106.1,35.71 102.11,35.71 101.13,34.73 101.13,33.79 100.1,32.77 100.1,22.76 v1(100.56,22.3)
PRG1_RGMII1_TD2: length 37.8
  TOP w0.102: U18.V6 85.39,28.78 v2(85.36,28.82)
  L03_SIG1 w0.121: v2(85.36,28.82) 85.73,28.45 88.34,28.45 88.98,27.81 100.24,27.81 v1(100.63,27.41)
  BOTTOM w0.135: U40.38 105.61,33.34 105.12,33.83 105.12,34.02 105.88,34.78 105.88,34.99 105.7,35.17 105.51,35.17 104.74,34.4 104.55,34.4 103.9,35.05 101.9,35.05 101.4,34.54 101.4,32.15 101.21,31.96 100.61,31.96 100.47,31.83 100.47,31.56 100.61,31.42 101.21,31.42 101.35,31.29 101.35,31.02 101.21,30.89 100.61,30.89 100.47,30.75 100.47,30.48 100.61,30.35 101.06,30.35 101.19,30.21 101.19,29.94 101.06,29.81 100.61,29.81 100.47,29.67 100.47,29.4 100.61,29.27 101.21,29.27 101.35,29.14 101.35,28.87 101.21,28.73 100.61,28.73 100.47,28.6 100.47,28.33 100.61,28.19 101.27,28.19 101.42,28.04 101.42,27.75 101.08,27.41 v1(100.63,27.41)
PRG1_RGMII1_TD3: length 37.9
  TOP w0.102: 87.74,28.77 87.65,28.86 U18.AA7
  TOP w0.135: 87.74,28.77 89.84,26.67 95.68,26.67 97.22,28.2 101.91,28.2 103.3,29.59 103.3,31.22 104.04,31.95 106.17,31.95 106.83,31.29 106.83,29.59 107.14,29.29 109.58,29.29 109.91,29.62 109.91,31.78 109.63,32.05 106.73,32.05 106.2,32.59 v1(105.08,32.59)
  BOTTOM w0.135: v1(105.08,32.59) 105.33,32.34 U40.36
PRG1_RGMII1_TX_CTL: length 37.8
  TOP w0.102: U18.Y7 86.69,28.56 87.57,28.56 87.74,28.39
  TOP w0.135: 87.74,28.39 89.79,26.34 95.96,26.34 97.54,27.91 102.41,27.91 103.26,27.07 106.37,27.07 106.56,27.26 106.56,27.63 106.43,27.76 104.76,27.76 104.6,27.92 104.6,28.19 104.73,28.33 106.43,28.33 106.56,28.46 106.56,28.7 106.4,28.86 104.73,28.86 104.6,29 104.6,29.24 104.73,29.38 106.43,29.38 106.56,29.51 106.56,29.78 106.43,29.92 105.39,29.92 105.26,30.05 105.26,30.32 105.39,30.45 106.39,30.45 106.53,30.59 106.53,31.01 106.2,31.34 v1(105.32,31.34)
  BOTTOM w0.135: U40.34 v1(105.32,31.34)
PRG1_RGMII1_TXC: length 37.7
  L03_SIG1 w0.121: v1(92.38,27.13) 92.82,27.13 93,26.94 101.66,26.94 101.98,26.62 102.87,26.62 103.6,25.89 104.45,25.89 104.67,26.11 104.67,26.75 104.4,27.02 102.42,27.02 v1(102.11,27.33)
  BOTTOM w0.135: U40.32 105.1,30.34 104.47,30.96 103.23,30.96 101.79,29.53 101.79,28.96 101.93,28.82 102.86,28.82 103,28.69 103,28.42 102.86,28.28 101.93,28.28 101.79,28.15 101.79,27.65 v1(102.11,27.33) ; v1(92.38,27.13) 93.01,26.49 93.01,24.82 92.56,24.36 90.17,24.36 89.93,24.6 89.93,25.35 90.06,25.48 91.69,25.48 91.82,25.62 91.82,25.89 91.69,26.02 90.19,26.02 90.06,26.16 R286.2
PRG_CPSW_RGMII1_MUX_SEL: length 44
  TOP w0.102: U18.AA11 87.12,30.63 87.57,30.63 87.58,30.63
  TOP w0.135: v1(98.73,32.56) 96.21,30.04 89.16,30.04 88.57,30.63 87.58,30.63
  BOTTOM w0.135: 112.03,28.74 R250.2 111.36,28.7 111.23,28.84 U40.10 ; 112.03,28.74 111.44,29.34 U40.9 ; 112.03,28.74 112.03,29.1 112.24,29.31 112.95,29.31 113.47,29.82 113.47,34.62 110.06,38.02 103.3,38.02 98.73,33.45 v1(98.73,32.56)
QSPI_RST_N: length 3.7
  TOP w0.135: v1(78.49,49.25) 78.51,49.28 U2.3
  BOTTOM w0.135: v1(78.49,49.25) 77.64,49.25 U31.4
R_BP_CONN_1_PORZ: length 3
  TOP w0.135: U1.3 27.94,57.29 27.78,57.12 R8.2 R4.1
R_BP_CONN_2_PORZ: length 3.2
  TOP w0.135: U1.6 R3.1 R2.2
SENCE3_IP: length 4
  BOTTOM w0.135: R188.2 21.37,52.95 20.24,54.08 U27.8
SOC_ADC0_AIN0: length 62.4
  TOP w0.102: 80.39,36.7 U18.H21
  TOP w0.135: v1(52.78,23.49) 51.59,22.3 45.17,22.3 43.65,20.78 R143.2 R142.1 ; 80.39,36.7 80.39,38.5 79.96,38.94 79.96,43.05 78.11,44.91 72.39,44.91 71.56,44.08 67.73,44.08 67.21,43.56 64.41,43.56 63.63,42.77 v1(63.63,41.76) 63.63,41.1 C28.1
  BOTTOM w0.135: v1(52.78,23.49) 55.41,26.12 55.41,34.98 62.18,41.76 v1(63.63,41.76)
SOC_ADC0_AIN1: length 48.1
  TOP w0.102: U18.F19 79.79,34.86 v2(79.83,34.89)
  TOP w0.135: v1(58.72,23.39) 57.84,22.51 57.84,21.26 57.37,20.78 R153.1 R152.2
  L03_SIG1 w0.102: 79.83,35.39 v2(79.83,34.89)
  L03_SIG1 w0.121: v1(69.14,41.66) 72.03,41.66 73.65,40.03 73.65,39.47 74.27,38.84 77.83,38.84 79.38,37.3 79.38,35.84 79.83,35.39
  BOTTOM w0.135: v1(58.72,23.39) 58.72,24.08 60.78,26.14 60.78,29.72 61.33,30.26 61.33,39 61.87,39.54 66.21,39.54 68.33,41.66 v1(69.14,41.66) 70.62,43.13 C118.1
SOC_ADC0_AIN2: length 59.1
  TOP w0.102: U18.F21 79.2,36.06 79.2,36.1 78.7,36.6 78.7,36.7
  TOP w0.135: v1(67.87,42.34) 68.53,43 72.36,43 73.19,43.83 77.66,43.83 78.7,42.78 78.7,36.7 ; v1(53.85,23.27) 52.55,21.97 47.58,21.97 46.39,20.78 R145.1 R144.2
  BOTTOM w0.135: C110.1 67.61,43.05 67.87,42.79 v1(67.87,42.34) 66.31,40.78 62.35,40.78 59.94,38.38 59.94,37.29 59.51,36.86 59.51,26.76 56.83,24.08 56.41,24.08 55.28,22.95 54.17,22.95 v1(53.85,23.27)
SOC_ADC0_AIN3: length 56.6
  TOP w0.102: U18.F20 79.67,35.64 79.67,35.98 78.97,36.68 78.97,36.7
  TOP w0.135: v1(54.91,23.39) 53.22,21.7 50.05,21.7 49.14,20.78 R147.1 R146.2 ; v1(66.27,42.52) 67.36,42.52 68.11,43.27 72,43.27 72.83,44.1 77.77,44.1 78.97,42.9 78.97,36.7
  BOTTOM w0.135: v1(54.91,23.39) 58.22,26.7 58.22,37.03 62.24,41.05 64.88,41.05 66.27,42.44 v1(66.27,42.52) 66.11,42.68 C108.1
SOC_ADC0_AIN4: length 64.1
  TOP w0.102: 79.68,36.7 80.08,36.3 80.08,35.68 U18.H20
  TOP w0.135: R148.2 R149.1 51.88,20.78 52.51,21.41 54.01,21.41 55.99,23.39 v1(56.44,23.39) ; C33.1 65.14,41.05 64.26,41.94 v1(64.26,42.42) 64.26,42.87 64.68,43.28 67.31,43.28 67.84,43.81 71.67,43.81 72.5,44.64 77.99,44.64 79.53,43.1 79.53,37.36 79.53,36.86 79.68,36.7
  BOTTOM w0.135: v1(56.44,23.39) 55.63,22.58 52.76,22.58 52.2,23.14 52.2,24.08 52.76,24.64 52.76,32.71 62.46,42.42 v1(64.26,42.42)
SOC_ADC0_AIN5: length 50.5
  TOP w0.102: U18.E21 78.89,36.12 78.44,36.58 78.44,36.7
  TOP w0.135: v1(57.45,23.39) 57.45,22.89 56.72,22.15 55.99,22.15 54.62,20.78 R151.1 R150.2 ; v1(68.86,42.57) 72.42,42.57 73.41,43.56 77.55,43.56 78.44,42.67 78.44,36.7
  BOTTOM w0.135: v1(57.45,23.39) 60.5,26.44 60.5,30.1 61.06,30.65 61.06,39.11 62.46,40.51 66.8,40.51 v1(68.86,42.57) 69.11,42.82 C117.1
SOC_ADC0_AIN6: length 58.2
  TOP w0.102: 79.27,36.7 79.88,36.1 79.88,35.38 U18.G20
  TOP w0.135: R154.2 R155.1 60.3,21.01 60.3,22.73 58.57,24.46 v1(54.97,24.46) ; C35.1 66.65,41.05 66.18,41.52 65.82,41.52 v1(65.28,42.06) 65.28,42.51 65.77,43 67.41,43 67.95,43.54 71.79,43.54 72.61,44.37 77.88,44.37 79.24,43.01 79.24,36.73 79.27,36.7
  BOTTOM w0.135: v1(54.97,24.46) 55.68,25.17 55.68,34.87 62.13,41.33 64.54,41.33 v1(65.28,42.06)
SOC_ADC0_AIN7: length 51.7
  TOP w0.102: U18.E20 78.58,35.68 78.58,36.15 78.16,36.57 78.16,36.7
  TOP w0.135: 78.16,36.7 78.16,36.71 78.16,42.56 77.44,43.29 73.85,43.29 72.67,42.11 v1(70.43,42.11) 69.37,41.05 C36.1 ; R156.2 R157.1 63.22,21.19 63.22,22.33 60.91,24.64 v1(59.99,24.64)
  BOTTOM w0.135: v1(59.99,24.64) 61.77,26.42 61.77,29.77 62.36,30.35 62.36,36.48 61.6,37.24 61.6,38.89 61.98,39.27 67.41,39.27 69.94,41.8 70.12,41.8 v1(70.43,42.11)
SOC_CLKIN: length 5.6
  TOP w0.102: 77.8,36.7 77.8,36.64 78.38,36.06 78.38,35.38 U18.D20
  TOP w0.135: 77.8,36.7 77.24,37.26 77.24,39.67 77.42,39.86 U11.4
SOC_CLKIN_BUFF: length 67.6
  TOP w0.135: v1(76.12,41.02) U11.2 ; R46.2 v1(115.27,47.37)
  L03_SIG1 w0.121: v1(76.12,41.02) 76.12,42.82 74.19,44.75 73.41,44.75 69.8,48.36 69.8,49.33 70.31,49.83 71.7,49.83 72.44,49.1 77.34,49.1 77.61,48.83 79.15,48.83 79.65,49.33 82.04,49.33 83.59,47.77 83.59,47.17 85.72,45.03 87.63,45.03 88.01,44.65 88.01,43.7 88.43,43.28 90.09,43.28 90.45,43.64 90.45,44.3 90.63,44.48 91.67,44.48 91.87,44.28 91.87,43.49 92.23,43.13 93.24,43.13 93.57,43.47 93.57,44.24 93.88,44.54 105.72,44.54 106.7,43.57 109.95,43.57 112.95,46.57 114.46,46.57 v1(115.27,47.37)
SOC_CLKIN_BUFF_R: length 2.6
  TOP w0.135: R46.1 116.93,47.96 117.16,48.19 U6.3
SOC_CPSW_RGMII1_TXC: length 1.5
  TOP w0.102: v2(85.93,31.32) 85.93,31.83 U18.W13
  BOTTOM w0.135: R287.1 86.21,31.04 v2(85.93,31.32)
SOC_EMU0: length 57.9
  TOP w0.102: U18.C5 77.89,27.41 v2(77.86,27.38)
  TOP w0.135: U16.5 28.79,35.14 29.69,34.24 29.69,33.27 30.76,32.21 v1(31.39,32.21)
  L03_SIG1 w0.121: v2(77.86,27.38) 74.67,24.19 73.37,24.19 71.59,25.96 69.42,25.96 66.85,28.53 65.92,28.53 65.18,29.27 65.18,30.32 63.84,31.66 37.25,31.66 36.7,32.21 v1(31.39,32.21)
SOC_EMU1: length 65.2
  TOP w0.102: U18.B3 77.11,27.14 76.77,27.14
  TOP w0.114: 76.77,27.14 76.34,26.71 76.34,25.97 76.05,25.68
  TOP w0.135: U16.4 31.61,35.14 v1(32,35.53) ; v1(73.56,19.66) 73.92,20.02 73.92,23.55 76.05,25.68
  L03_SIG1 w0.121: v1(73.56,19.66) 73.56,21.89 72.06,23.39 72.06,24.43 70.79,25.7 69.27,25.7 66.69,28.28 65.81,28.28 64.9,29.19 64.9,30.24 63.74,31.4 37.13,31.4 36.79,31.74 31.2,31.74 30.89,32.05 30.89,34.42 v1(32,35.53)
SOC_I2C0_SCL: length 223.6
  TOP w0.135: v1(147.02,19.86) 146.3,20.57 R141.1 ; R93.1 67.84,35.53 v1(67.21,36.17) 66.75,36.63 65.48,36.63 64.69,35.84 U17.6
  L03_SIG1 w0.121: v1(156.82,52.03) 153.75,48.96 v1(153.75,41.27) 153.75,27.04 147.02,20.3 v1(147.02,19.86) ; v1(67.21,36.17) 67.21,37.48 65.17,39.52 62.79,39.52 61.32,41 57,41 54.33,43.66 45.87,43.66 45.21,44.32 42.07,44.32 41.64,43.89 39.04,43.89 v1(38.05,44.88)
  BOTTOM w0.135: v1(38.05,44.88) 38.05,45.7 37.52,46.23 37.52,47.85 40.44,50.77 40.44,53.09 38.66,54.86 38.66,59.64 40.06,61.04 71.71,61.04 74.35,58.4 82.48,58.4 83.61,59.54 83.61,60.33 86.06,62.78 136.69,62.78 147.43,52.03 v1(156.82,52.03) ; U35.15 v1(153.75,41.27) ; R237.2 67.23,36.2 v1(67.21,36.17)
SOC_I2C0_SCL_BP: length 27.8
  TOP w0.135: R141.2 144.57,20.54 143.43,19.4 143.43,16.56 141.78,14.91 141.78,13.64 139.93,11.79 132.2,11.79 129.32,14.67 125.78,14.67 J5.17
SOC_I2C0_SCL_RC: length 9.2
  TOP w0.102: U18.B16 77.38,33.38 76.23,33.38 76.16,33.44 76.05,33.44
  TOP w0.135: R93.2 C47.1 69.94,34.12 70.18,33.88 72.85,33.88 73.29,33.44 76.05,33.44
SOC_I2C0_SDA: length 228
  TOP w0.135: R158.1 v1(146.23,19.08) ; R97.1 68.96,32.68 67.49,34.15 67.49,35.05 66.37,36.17 v1(65.91,36.17) 65.6,36.17 65.34,35.92 U17.5
  L03_SIG1 w0.121: v1(146.23,19.08) 148.6,19.08 156.04,26.51 156.04,40.74 156.13,40.83 v1(156.13,41.27) 156.13,48.62 v1(158.8,51.28) ; v1(37.91,43.86) 39.4,42.37 55.04,42.37 56.82,40.59 61.27,40.59 62.59,39.27 65.06,39.27 65.91,38.42 v1(65.91,36.17)
  BOTTOM w0.135: v1(158.8,51.28) 147.73,51.28 136.5,62.51 86.18,62.51 83.88,60.22 83.88,59.4 82.62,58.14 74.19,58.14 71.55,60.77 40.3,60.77 38.93,59.4 38.93,55.22 40.74,53.4 40.74,50.7 37.8,47.75 37.8,46.61 38.48,45.92 38.48,44.42 v1(37.91,43.86) ; v1(65.91,36.17) R238.2 ; U35.2 v1(156.13,41.27)
SOC_I2C0_SDA_BP: length 24.8
  TOP w0.135: J5.19 129.67,10.9 141.36,10.9 143.16,12.7 143.16,15.67 144.52,17.04 R158.2
SOC_I2C0_SDA_RC: length 9.9
  TOP w0.102: U18.B15 77.08,33.17 76.05,33.17
  TOP w0.135: 76.05,33.17 73.17,33.17 72.79,33.55 71.88,33.55 70.69,32.36 70.22,32.36 R97.2 69.94,33.32 70.03,33.41 v1(70.03,33.41)
  BOTTOM w0.135: v1(70.03,33.41) 70.03,33.43 70.04,33.43 C161.1
SOC_I2C1_SCL: length 135.5
  TOP w0.102: 76.05,34.04 76.07,34.06 76.7,34.06 U18.A17
  TOP w0.135: J1.17 59.05,11.45 39.89,11.45 39.09,12.24 39.09,19.41 42.21,22.53 v1(42.21,34.34) ; R88.2 v1(69.55,37.11) 69.9,36.75 70.08,36.75 72.06,34.77 72.09,34.77 72.1,34.76 72.91,34.76 73.63,34.04 76.05,34.04 ; v1(7.42,45.16) 8.08,44.51 U9.2
  L03_SIG1 w0.121: v1(69.55,37.11) 69.55,35.92 69.01,35.38 64.83,35.38 62.88,37.33 62.03,37.33 61.19,38.18 58.1,38.18 57.33,37.41 57.33,34.62 56.87,34.16 56.03,34.16 55.45,34.75 55.45,35.41 55,35.86 53.59,35.86 52.07,34.34 v1(42.21,34.34) 41.58,34.98 41.58,36.3 39.65,38.23 39.65,39.59 36.58,42.66 32.55,42.66 31.15,41.26 27.53,41.26 26.41,42.37 19.13,42.37 18.82,42.06 10.52,42.06 v1(7.42,45.16)
SOC_I2C1_SDA: length 139.1
  TOP w0.102: U18.B18 77.11,34.64 76.05,34.64
  TOP w0.135: 76.05,34.64 75.77,34.64 75.11,35.31 72.29,35.31 70.33,37.26 70.33,37.44 70,37.77 70,38.1 v1(69.6,38.51) R82.2 ; J1.19 61.32,11.18 39.78,11.18 38.79,12.17 38.79,19.61 41.53,22.35 41.53,34.92 v1(42.21,35.61) ; U9.3 8.34,45.16 v1(8.34,45.16)
  L03_SIG1 w0.121: v1(8.34,45.16) 9.99,43.51 11.94,43.51 13.11,42.34 18.64,42.34 18.93,42.63 26.52,42.63 27.63,41.51 30.87,41.51 32.28,42.92 36.68,42.92 40.06,39.55 40.06,38.33 42.21,36.17 v1(42.21,35.61) 42.98,34.85 52.1,34.85 53.36,36.11 55.18,36.11 55.73,35.56 55.73,34.83 56.05,34.5 56.78,34.5 56.97,34.7 56.97,37.41 57.99,38.43 61.39,38.43 62.23,37.59 62.98,37.59 64.91,35.66 68.78,35.66 69.09,35.97 69.09,38 v1(69.6,38.51)
SOC_I2C1_TA_SCL: length 15.2
  TOP w0.135: v1(9.3,52.17) 9.33,52.14 9.33,48.69 9.33,48.11 9.33,48.1 9.33,47.56 8.17,46.4 8,46.4 6.11,44.51 U9.7
  BOTTOM w0.135: R187.2 v1(9.3,52.17) 9.01,52.45 J15.36
SOC_I2C1_TA_SDA: length 17
  TOP w0.135: U9.6 6.11,45.16 7.69,46.74 8.03,46.74 9.06,47.77 9.06,48.22 9.06,48.22 9.06,50.96 8.76,51.26 8.76,53.37 v1(9.45,54.05)
  BOTTOM w0.135: R182.2 v1(9.45,54.05) 8.15,54.05 7.56,53.45 J15.38
SOC_PRG1_RGMII1_TXC: length 4.6
  TOP w0.102: v2(85.93,28.82) 85.93,28.39 U18.W6
  BOTTOM w0.135: v2(85.93,28.82) 85.93,28.37 87.43,26.87 R286.1
SOC_RESET_REQZ: length 22.6
  TOP w0.102: v2(77.86,34.33) 77.89,34.28 U18.C17
  TOP w0.135: U13.2 59.26,37.56 v1(59.44,37.39) 59.44,36.37 TP24.1
  L03_SIG1 w0.121: v1(59.44,37.39) 59.75,37.08 62.77,37.08 64.78,35.07 71.07,35.07 71.09,35.05 77.14,35.05 v2(77.86,34.33)
SOC_RESETSTATZ: length 15.9
  TOP w0.102: v2(78.44,34.89) 78.47,34.86 U18.E19
  TOP w0.135: v1(71.96,39.29) 71.96,39.74 71.7,40.01 TP13.1
  L03_SIG1 w0.121: v1(71.96,39.29) 71.96,38.3 71.53,37.87 70.62,37.87 70.37,37.62 70.37,36.77 71.09,36.05 73.91,36.05 74.19,36.33 77,36.33 v2(78.44,34.89)
  BOTTOM w0.135: R234.2 71.14,39.86 71.7,39.29 v1(71.96,39.29)
SOC_TCK: length 27.6
  TOP w0.102: U18.C6 77.89,28.78 v2(77.86,28.82)
  TOP w0.135: v1(70.08,27.15) 69.29,27.15 67.13,24.99 67.13,24.4 67.32,24.22 67.32,18.2 67.12,18 67.12,14.87 67.51,14.48 69.79,14.48 70.31,15 R162.1
  L03_SIG1 w0.121: v2(77.86,28.82) 77.18,28.82 75.03,26.67 73.05,26.67 71.85,27.87 70.8,27.87 v1(70.08,27.15)
SOC_TDI: length 17.1
  TOP w0.102: 76.05,25.25 76.55,25.75 76.55,26.52 U18.A3
  TOP w0.135: U25.5 70.69,16.16 71.57,15.28 72.93,15.28 74.19,16.53 74.19,23.38 76.05,25.25
SOC_TDO: length 1.8
  BOTTOM w0.135: U42.2 68.49,20.57 69.13,19.94 R271.1
SOC_TMS: length 17.1
  TOP w0.114: 76.1,26.77 76.68,27.36 U18.B4
  TOP w0.135: U25.6 71.34,16.14 71.93,15.55 72.82,15.55 73.1,15.82 73.1,20.02 73.65,20.56 73.65,23.66 76.1,26.11 76.1,26.77
SOC_TRST#: length 22
  TOP w0.102: U18.B6 77.11,28.64 76.67,28.64 76.3,28.27 76.08,28.27 76.05,28.24
  TOP w0.135: 76.05,28.24 75.23,28.24 73.91,26.92 72.96,26.92 R120.2 72.71,26.25 72.47,26.01 68.58,26.01 67.42,24.85 67.42,24.5 67.59,24.33 67.59,21.82 69.34,20.07 70.61,20.07 71.99,18.69 U25.7
SPI0_CLK: length 73.8
  TOP w0.102: 76.05,28.86 76.31,28.86 76.52,29.07 77.1,29.07 U18.B8
  TOP w0.135: v1(66.5,23.06) 66.5,25.12 69.36,27.98 71.19,27.98 71.28,28.07 74.19,28.07 74.99,28.86 76.05,28.86
  L03_SIG1 w0.121: J5.13 117.71,11.68 100.35,11.68 99.11,12.92 89.57,12.92 87.13,15.36 86.99,15.51 74.43,15.51 69,20.94 69,22.08 68.02,23.06 v1(66.5,23.06)
SPI0_CS1: length 168.2
  TOP w0.102: U18.B7 76.61,28.86 76.32,28.58 76.07,28.58 76.05,28.59
  TOP w0.135: 76.05,28.59 75.2,28.59 73.8,27.19 73.22,27.19 72.7,27.71 69.47,27.71 66.85,25.1 66.85,24.1 67.05,23.91 67.05,18.31 66.85,18.11 66.85,14.76 67.51,14.1 77.9,14.1 78.85,15.05 82.49,15.05 85.82,11.72 95.72,11.72 96.24,11.2 99.24,11.2 100.86,9.58 v1(127.86,9.58)
  L03_SIG1 w0.121: v1(127.89,19.2) v1(114.63,19.2)
  BOTTOM w0.135: v1(127.89,19.2) 128.47,18.62 128.47,10.19 v1(127.86,9.58) ; J6.6 107.67,60.83 103.84,60.83 102.94,59.94 102.94,55.42 103.45,54.91 107.49,54.91 110.67,51.73 110.67,40.66 113.74,37.6 113.74,24.33 112.43,23.02 112.43,19.65 113.28,18.8 114.23,18.8 v1(114.63,19.2)
SPI0_D0: length 104
  TOP w0.102: 76.05,29.13 76.29,29.13 76.52,29.36 U18.A8
  TOP w0.135: v1(66.45,27.84) 68.83,27.84 69.24,28.25 71.08,28.25 71.16,28.33 74.08,28.33 74.88,29.13 76.05,29.13
  BOTTOM w0.135: v1(66.45,27.84) 65.66,28.63 65.66,32.69 69.04,36.07 69.04,39.19 69.88,40.04 69.88,40.55 72.54,43.21 72.54,44.68 71.53,45.7 68.3,45.7 63.38,50.62 63.38,53.73 66.66,57.01 82.6,57.01 83.04,57.01 84.96,58.93 84.96,59.77 86.62,61.43 114.7,61.43 J6.12
SPI0_D1: length 104.2
  TOP w0.102: U18.C9 77.89,30.28 v2(77.86,30.32)
  TOP w0.135: J6.14 117.4,61.27 85.5,61.27 81.91,57.68 76.81,57.68 74.98,59.51 69.72,59.51 67.88,57.67 67.88,44.94 66.78,43.84 63.49,43.84 62.81,43.15 62.81,38.26 62.41,37.86 62.41,35.33 v1(61.93,34.85)
  L03_SIG1 w0.121: v2(77.86,30.32) 77.08,30.32 75.32,28.56 68.26,28.56 67.18,29.64 67.18,32.7 66.49,33.4 64.34,33.4 62.89,34.85 v1(61.93,34.85)
SPI3_CLK: length 44.4
  TOP w0.102: v2(83.37,26.82) 83.32,26.86 U18.N3
  L03_SIG1 w0.121: v1(86.82,18.57) 86.82,19.56 85.14,21.23 85.14,23.7 83.37,25.47 v2(83.37,26.82)
  BOTTOM w0.135: v1(86.82,18.57) 83.84,15.59 78.38,15.59 76.24,13.46 67.44,13.46 65.93,11.95 57.5,11.95 J1.13
SPI3_CS0: length 86.9
  TOP w0.102: 78.53,25.02 78.63,25.12 78.63,25.6 U18.E1
  TOP w0.135: 78.53,25.02 78.53,25.01 77,23.48 76.69,23.48 76.17,22.96 v1(76.17,16.21)
  BOTTOM w0.135: J2.6 44.55,57.91 44.55,53.52 48.32,49.74 48.32,41.24 47.37,40.29 47.37,38.17 44.33,35.13 44.33,23.21 49.97,17.57 64.2,17.57 67.4,14.36 74.32,14.36 v1(76.17,16.21)
SPI3_CS1: length 91.7
  TOP w0.102: U18.N4 83.35,27.36 v2(83.37,27.38)
  L03_SIG1 w0.121: v1(84.81,19.23) 84.1,19.94 84.1,24.28 82.85,25.53 82.85,26.87 v2(83.37,27.38)
  BOTTOM w0.135: v1(84.81,19.23) 82.14,19.23 81.53,18.62 81.2,18.62 80.96,18.86 80.43,18.86 79.97,18.4 74.11,18.4 73.1,17.4 66.69,17.4 64.91,19.18 63.75,19.18 62.86,20.07 51.1,20.07 47.4,23.77 47.4,32.26 47.4,32.26 47.4,33.17 49.68,35.45 49.68,35.71 56.15,42.18 56.15,50.79 59.79,54.43 59.79,57.91 J2.18
SPI3_D0: length 93.3
  TOP w0.102: 83.17,25.02 83.17,25.59 U18.N1
  TOP w0.135: v1(85.81,18.33) 86.23,18.76 86.23,19.48 83.69,22.02 83.69,24 83.17,24.53 83.17,25.02
  BOTTOM w0.135: v1(85.81,18.33) 85.66,18.48 82.16,18.48 81.03,17.35 78.05,17.35 77.69,16.98 74.79,16.98 73.1,15.29 69.97,15.29 69,16.26 66.31,16.26 64.46,18.11 64.27,18.11 51.49,18.11 44.87,24.73 44.87,33.92 49.72,38.77 49.72,50.56 52.17,53.01 52.17,57.91 J2.12
SPI3_D1: length 92.5
  TOP w0.102: U18.N2 82.61,26.08 82.61,25.59 82.9,25.31 82.9,25.02
  TOP w0.135: 82.9,25.02 82.9,24.42 83.41,23.9 83.41,21.56 v1(85.73,19.25)
  BOTTOM w0.135: J2.14 54.71,57.91 54.71,54.71 50.01,50.01 50.01,38.68 45.14,33.81 45.14,24.84 51.6,18.37 64.57,18.37 66.36,16.59 73.71,16.59 74.37,17.25 77.57,17.25 77.94,17.62 80.91,17.62 82.06,18.76 85.24,18.76 v1(85.73,19.25)
SYNC1_OUT: length 92.6
  TOP w0.102: 76.05,34.36 U18.A18
  TOP w0.135: v1(67.67,10.79) 67.67,11.24 65.18,13.73 65.18,18.03 64.52,18.69 64.52,22.02 60.59,25.95 60.59,30.72 62.71,32.84 62.71,37.74 64.21,39.25 65.3,39.25 66.83,37.72 69.65,37.72 70.05,37.31 70.05,37.16 72.19,35.03 75.01,35.03 75.67,34.36 76.05,34.36
  BOTTOM w0.135: v1(67.67,10.79) 69.27,9.19 73.91,9.19 78.96,14.24 82.58,14.24 86.59,10.22 103.55,10.22 J5.3
SYNC2_OUT: length 106.4
  TOP w0.135: R140.2 149.98,21.71 144.42,16.15 v1(144.42,9.19)
  L03_SIG1 w0.121: J1.18 62.36,14.71 62.36,12.27 63.25,11.38 70.15,11.38 73.26,14.49 86.54,14.49 90.46,10.57 90.8,10.23 99.62,10.23 99.9,10.51 138.11,10.51 139.42,9.19 v1(144.42,9.19)
SYNC3_OUT: length 117.2
  TOP w0.135: R131.2 160.87,20.59 159.77,19.48 v1(159.77,10.41)
  L03_SIG1 w0.121: J1.20 65.18,14.43 65.18,12.42 65.84,11.76 69.82,11.76 72.81,14.74 86.65,14.74 90.08,11.31 99.07,11.31 99.53,10.84 138.2,10.84 139.42,9.63 145.42,9.63 146.48,8.56 157.91,8.56 v1(159.77,10.41)
SYS_BOOTMODE3: length 33.2
  TOP w0.135: v1(27.66,51.69) 27.97,51.37 27.97,51.32 28.14,51.15 U4.3 ; R16.1 v1(13.84,51.82) 14.35,51.31 SW4.1
  L03_SIG1 w0.121: v1(27.66,51.69) 22.3,51.69 22.17,51.82 v1(13.84,51.82)
  BOTTOM w0.135: U26.2 25.57,56.84 26.06,57.33 28.96,57.33 29.87,56.41 29.87,51.1 28.96,50.19 28.17,50.19 27.66,50.7 v1(27.66,51.69)
SYS_BOOTMODE4: length 28.3
  TOP w0.135: SW4.2 14.12,50.04 v1(13.84,50.32) R27.1 ; U4.4 v1(28.57,50.65)
  L03_SIG1 w0.121: v1(13.84,50.32) 26.24,50.32 26.57,50.65 v1(28.57,50.65)
  BOTTOM w0.135: U26.3 26.07,56.7 26.38,57.01 26.39,57.01 26.42,57.04 28.08,57.04 29.51,55.6 29.51,51.6 v1(28.57,50.65)
SYS_BOOTMODE5: length 33.8
  TOP w0.135: R33.1 v1(13.84,48.82) 15.42,48.82 SW4.3 ; v1(29.08,52.76) 27.96,52.76 27,51.8 27,50.98 27.82,50.15 U4.5
  L03_SIG1 w0.121: v1(13.84,48.82) 14.93,49.91 18.6,49.91 19.22,49.28 25.59,49.28 26.63,50.33 27.85,50.33 28.09,50.09 28.78,50.09 29.08,50.39 v1(29.08,52.76)
  BOTTOM w0.135: v1(29.08,52.76) 29.08,55.48 27.8,56.77 26.7,56.77 26.57,56.65 U26.4
SYS_BOOTMODE6: length 27.5
  TOP w0.135: SW4.4 14.02,47.5 v1(13.84,47.32) R47.1 ; U4.6 v1(28.57,49.65)
  L03_SIG1 w0.121: v1(28.57,49.65) 27.99,49.65 27.58,50.07 26.78,50.07 25.7,49 25.66,49 25.66,49 22.52,49 22.48,49 21.64,49 21.64,49 19.15,49 19.15,49 15.52,49 v1(13.84,47.32)
  BOTTOM w0.135: v1(28.57,49.65) 28.12,49.65 27.22,50.55 27.22,51.87 28.73,53.37 28.73,54.92 28.39,55.26 U26.5
SYS_BOOTMODE7: length 26.2
  TOP w0.135: SW4.5 14.25,46.23 v1(13.84,45.82) R52.1 ; 29.37,49.15 27.82,49.15 v1(27.33,49.64)
  L03_SIG1 w0.121: v1(27.33,49.64) 26.83,49.64 25.93,48.73 16.76,48.73 v1(13.84,45.82)
  BOTTOM w0.135: U26.7 28.19,54.26 28.45,54 28.45,53.47 26.92,51.95 26.92,50.05 v1(27.33,49.64)
SYS_BOOTMODE8: length 27.5
  TOP w0.135: R66.1 v1(13.84,44.32) 14.48,44.96 SW4.6 ; U4.8 28,48.65 v1(27.46,48.11)
  L03_SIG1 w0.121: v1(13.84,44.32) 15.67,44.32 17.75,46.41 25.76,46.41 v1(27.46,48.11)
  BOTTOM w0.135: v1(27.46,48.11) 27.46,48.67 25.96,50.16 25.96,51.36 27.89,53.29 27.89,53.62 27.75,53.76 U26.8
SYS_BOOTMODE9: length 27.3
  TOP w0.135: SW4.7 14.71,43.69 v1(13.84,42.82) R69.1 ; U4.9 28.16,48.15 v1(27.23,47.22)
  L03_SIG1 w0.121: v1(13.84,42.82) 14.63,42.82 17.93,46.13 26.14,46.13 v1(27.23,47.22)
  BOTTOM w0.135: U26.9 26.57,52.37 25.65,51.45 25.65,49.96 26.9,48.72 26.9,47.55 v1(27.23,47.22)
TA_BOOTMODE_I2C_SCL: length 27.9
  TOP w0.135: v1(24.31,53.16) 24.31,53.61 21.69,56.23 19.14,56.23 15.47,59.89 11.61,59.89 7.59,55.88 7.59,53.54 v1(8.02,53.11)
  BOTTOM w0.135: U26.12 24.41,53.06 v1(24.31,53.16) ; R186.2 v1(8.02,53.11) 7.87,52.95 J15.37
TA_BOOTMODE_I2C_SDA: length 24.6
  TOP w0.135: v1(23.55,53.67) 21.26,55.96 19.02,55.96 15.36,59.62 11.72,59.62 8.02,55.93 v1(8.02,54.99)
  BOTTOM w0.135: U26.13 23.63,53.76 v1(23.55,53.67) ; J15.39 7.45,53.95 8.02,54.53 v1(8.02,54.99) R178.2
TA_GPIO2: length 3.9
  TOP w0.135: v1(8.02,49.35) 7.46,48.79 TP6.1
  BOTTOM w0.135: J15.31 7.42,49.95 v1(8.02,49.35) R197.1
TA_GPIO3: length 43
  L03_SIG1 w0.121: TP3.1 36.43,57.17 35.81,57.79 31.72,57.79 31.06,57.12 25.94,57.12 25.38,57.68 15.62,57.68 11.48,53.54 11.48,51.37 10.4,50.29 v1(9.78,50.29)
  BOTTOM w0.135: J15.32 9.17,50.45 9.33,50.29 v1(9.78,50.29) R196.1 ; U28.1 36.97,52.38 36.43,52.93 TP3.1
TA_GPIO4: length 30.2
  TOP w0.135: v1(24.77,57.25) 23.5,57.25 21.67,59.08 16.66,59.08 15.58,60.16 11.5,60.16 6.58,55.24 6.58,52.68 v1(8.02,51.23)
  BOTTOM w0.135: R189.1 v1(8.02,51.23) 7.58,51.23 7.3,50.95 J15.33 ; U26.1 25.07,56.95 v1(24.77,57.25)
TA_PORZN: length 22.2
  TOP w0.135: v1(10.4,46.53) 11.35,47.48 11.35,55.23 10.72,55.85 10.72,58.19 11.57,59.04 v1(13.98,59.04)
  BOTTOM w0.135: Q8.3 v1(13.98,59.04) ; J15.27 6.87,47.95 8.29,46.53 v1(10.4,46.53) R211.1
TA_POWERDOWN: length 44.9
  TOP w0.135: v1(8.05,39.04) 16.08,39.04 16.92,38.2 16.92,37.44 17.64,36.72 39.47,36.72 40.75,38 R84.1
  BOTTOM w0.135: J15.26 6.87,47.45 7.87,46.45 7.87,39.22 v1(8.05,39.04)
TA_PWR_EN: length 3.4
  BOTTOM w0.508: U41.3 3.36,29.52 R251.2
TA_SOC_INTN: length 112
  L03_SIG1 w0.121: v1(66.32,8.43) 65.02,9.73 39.09,9.73 38.28,8.92 12.78,8.92 11.07,10.62 11.07,14.88 6.38,19.58 6.38,22.63 7.44,23.7 7.44,24.08 8.33,24.97 8.33,26.24 7.87,26.7 5.49,26.7 2.46,29.72 2.46,45.75 5.15,48.43 v1(8.63,48.43)
  BOTTOM w0.135: J15.30 6.96,49.45 7.99,48.43 v1(8.63,48.43) 8.65,48.41 R202.1 ; Q16.3 66.12,8.63 v1(66.32,8.43)
TA_WARMRESETN: length 33.5
  TOP w0.135: v1(8.02,47.47) 7.34,47.47 6.2,48.62 6.2,55.37 11.26,60.43 15.69,60.43 16.72,59.41 21.41,59.41 21.81,59.8 23.86,59.8 v1(24.18,59.49)
  BOTTOM w0.135: Q7.3 24.29,59.38 v1(24.18,59.49) ; J15.28 7.04,48.45 v1(8.02,47.47) R209.1
TCA6408_EXP_ADDR: length 2.1
  BOTTOM w0.135: U26.16 R177.2
TCA6408_EXP_INT: length 2.2
  BOTTOM w0.135: U26.11 25.57,52.32 24.94,51.69 R191.1
TEST_LED1_GREEN: length 113.6
  TOP w0.102: U18.U19 85.32,34.86 v2(85.35,34.89)
  L03_SIG1 w0.121: v2(85.35,34.89) 85.35,35.62 87.93,38.19 87.93,39.06 88.37,39.5 v1(88.87,39.5) ; v1(166.06,59.73) 164.09,61.7 104.6,61.7 100.61,57.71 v1(100.61,56.31)
  BOTTOM w0.135: R216.1 88.61,44.85 89.31,44.15 89.31,42.19 88.56,41.44 88.56,39.81 v1(88.87,39.5) 89.69,39.5 91.27,37.91 93.62,37.91 95.99,40.29 97.49,40.29 98.93,41.73 98.93,43.23 99.14,43.44 99.9,43.44 101.79,45.33 101.79,50.2 101.12,50.88 101.12,52.25 100.61,52.76 v1(100.61,56.31) ; Q6.3 R173.2 v1(166.06,59.73)
TEST_LED2_RED: length 160.3
  TOP w0.102: 76.05,29.4 76.27,29.4 76.44,29.57 76.6,29.57 U18.A9
  TOP w0.135: v1(66.09,28.96) 66.73,28.32 68.94,28.32 69.12,28.5 69.13,28.52 70.97,28.52 71.05,28.6 73.87,28.6 74.66,29.4 76.05,29.4
  L03_SIG1 w0.121: v1(101.98,59.89) 104.04,61.95 165.23,61.95 167.45,59.73 v1(170.81,59.73)
  BOTTOM w0.135: v1(101.98,59.89) 100.71,61.16 86.73,61.16 85.23,59.66 85.23,58.82 84.69,58.28 83.15,56.74 82.49,56.74 66.78,56.74 63.65,53.61 63.65,50.73 68.41,45.97 71.64,45.97 72.87,44.73 72.87,43.16 70.15,40.44 70.15,37.9 70.05,37.79 70.05,36.7 66.09,32.74 v1(66.09,28.96) ; v1(170.81,59.73) R172.2 Q5.3
TEST_LED3_RED: length 167.9
  TOP w0.102: U18.D1 78.39,25.26 78.16,25.02
  TOP w0.135: 78.16,25.02 76.89,23.75 76.58,23.75 75.64,22.81 75.64,16.1 76.27,15.48 77.76,15.48 78.41,16.13 82.93,16.13 86.26,12.8 98.51,12.8 100.79,10.51 133.73,10.51 135.7,8.54 160.06,8.54 v1(160.38,8.87)
  L03_SIG1 w0.121: v1(179.88,58.47) 178.71,57.3 169.03,57.3 158.04,46.31 158.04,23.26 159.48,21.82 159.48,20.28 160.38,19.37 v1(160.38,8.87)
  BOTTOM w0.135: Q9.3 182.84,58.41 R174.2 179.94,58.41 v1(179.88,58.47)
TEST_LED4_GREEN: length 151.5
  TOP w0.102: U18.F3 79.81,26.86 v2(79.85,26.82)
  L03_SIG1 w0.121: v2(79.85,26.82) 79.04,26.01 79.04,22.94 78.89,22.78 78.89,18.88 79.76,18.01 81.33,18.01 81.86,17.48 98.48,17.48 99.75,18.75 99.82,18.75 99.84,18.76 130.77,18.76 131.67,17.86 138.48,17.86 140.37,15.96 142.85,15.96 144.72,17.83 156.21,17.83 157.8,19.42 157.8,21.67 157.63,21.84 157.63,46.79 168.98,58.14 176.63,58.14 180.99,62.49 v1(181.65,62.49)
  BOTTOM w0.135: R165.2 180.86,62.49 v1(181.65,62.49) 182.1,62.49 182.32,62.27 Q4.3
TIMER_IO0: length 58.9
  TOP w0.102: v2(81.84,34.33) 81.81,34.36 U18.K18
  TOP w0.135: J6.1 102.92,56.64 99.85,53.57 96.93,53.57 95.91,54.58 94.13,54.58 93.92,54.37 93.92,52.22 94.05,52.09 94.32,52.09 94.46,52.22 94.46,53.65 94.59,53.78 94.86,53.78 94.99,53.65 94.99,52.22 95.13,52.09 95.4,52.09 95.53,52.22 95.53,53.65 95.67,53.78 95.94,53.78 96.07,53.65 96.07,51.69 95.94,51.55 94.05,51.55 93.92,51.42 93.92,50.28 93.48,49.84 91.39,49.84 90.81,49.25 v1(89.96,49.25)
  L03_SIG1 w0.121: v2(81.84,34.33) 82.01,34.49 82.01,38.89 82.35,39.23 82.35,45.69 v1(79.91,48.13)
  BOTTOM w0.135: v1(79.91,48.13) 82.5,50.72 86.56,50.72 87.58,49.71 87.93,49.71 88.39,49.25 v1(89.96,49.25) 89.96,49.25 90.1,49.39 R193.1
TIMER_IO1: length 59.4
  TOP w0.102: 81.36,36.7 81.39,36.67 81.39,35.64 81.39,35.64 U18.K20
  TOP w0.135: R19.1 89.51,51.21 v1(89.51,52.27) ; v1(78.71,46) 81.74,42.98 81.74,40.67 80.95,39.88 80.95,39.32 81.36,38.91 81.36,36.7
  L03_SIG1 w0.121: v1(89.51,52.27) 89.82,51.96 90.31,51.96 90.44,52.09 90.44,53.2 90.75,53.52 93.53,53.52 93.65,53.4 93.65,52.34 93.77,52.22 94.01,52.22 94.13,52.34 94.13,53.4 94.25,53.52 94.49,53.52 94.61,53.4 94.61,52.34 94.73,52.22 94.98,52.22 95.1,52.34 95.1,53.4 95.22,53.52 95.76,53.52 96.36,52.92 104.45,52.92 104.73,53.2 104.73,53.37 104,54.1 104,54.27 104.17,54.44 104.34,54.44 105.08,53.71 105.25,53.71 105.42,53.88 105.42,54.05 104.69,54.78 104.69,54.95 104.86,55.12 105.03,55.12 105.76,54.39 105.93,54.39 106.79,55.25 J6.3
  BOTTOM w0.135: v1(78.71,46) 78.05,46.66 78.05,47.7 82.63,52.27 v1(89.51,52.27)
TIMER_IO2: length 59.1
  TOP w0.102: U18.J19 81.4,34.86 v2(81.46,34.92)
  TOP w0.135: J6.5 106.25,53.57 101.96,53.57 100.78,52.4 100.59,52.4 99.92,53.07 99.73,53.07 99.54,52.88 99.54,52.69 100.21,52.02 100.21,51.83 100.02,51.64 99.83,51.64 99.03,52.44 98.84,52.44 98.65,52.25 98.65,52.05 99.45,51.25 99.45,51.06 99.29,50.9 99.1,50.9 98.27,51.72 98.08,51.72 97.89,51.53 97.89,51.29 98.69,50.49 98.69,50.3 98.28,49.9 94.29,49.9 93.96,49.57 92.27,49.57 v1(91.69,49)
  L03_SIG1 w0.121: v1(78.92,47.52) 79.93,47.52 82.09,45.36 82.09,39.34 81.75,39 81.75,35.21 v2(81.46,34.92)
  BOTTOM w0.135: v1(78.92,47.52) 80.19,47.52 83.08,50.42 86.49,50.42 87.31,49.6 87.48,49.43 87.83,49.43 88.47,48.79 91.04,48.79 91.25,49 v1(91.69,49) 91.57,49.12 R192.1
TIMER_IO3: length 59.6
  TOP w0.102: v2(80.33,34.89) 80.59,34.64 80.61,34.64 U18.J18
  TOP w0.135: v1(87.27,50.62) 89.07,48.82 91.13,48.82 91.44,48.51 91.9,48.51 92.69,49.3 94.07,49.3 94.4,49.63 98.62,49.63 102.11,53.11 108.34,53.11 J6.7
  L03_SIG1 w0.102: v2(80.33,34.89) 80.33,36.53 80.51,36.7
  L03_SIG1 w0.121: 80.51,36.7 80.51,38.79 80.41,38.9 80.41,40.1 81.07,40.76 81.07,41.28 79.98,42.37 78.61,42.37 78.16,42.82 78.16,45.03 78.56,45.44 79.45,45.44 79.78,45.77 v1(79.78,46.56)
  BOTTOM w0.135: v1(79.78,46.56) 79.04,46.56 78.49,47.12 78.49,47.7 82.63,51.84 86.06,51.84 v1(87.27,50.62) 87.92,49.98 88.05,49.98 R194.1
TIMER_IO4: length 27.6
  TOP w0.135: v1(90.93,53.06) 90.94,53.06 R20.1
  L03_SIG1 w0.121: v1(90.93,53.06) 92.33,53.06 93.47,51.92 95.81,51.92 96.45,52.56 105.04,52.56 107.88,55.4 113.17,55.4 J6.9
TIMER_IO4_R: length 31
  TOP w0.102: U18.J20 81.17,35.64 81.17,36.25 81,36.42 81,36.7
  TOP w0.135: 81,36.7 81,38.84 80.68,39.16 80.68,40.02 81.47,40.8 81.47,42.59 v1(79.04,45.02) ; R20.2 90.9,50.41 90.32,49.83 88.82,49.83 87.55,51.1 86.94,51.1 86.28,50.44 v1(86.28,49.86)
  BOTTOM w0.135: v1(79.04,45.02) 86.04,45.02 86.39,45.36 86.39,46.69 85.19,47.89 85.19,49.61 85.45,49.86 v1(86.28,49.86)
TIMER_IO5: length 59.4
  TOP w0.102: 80.7,36.7 80.7,36.12 80.7,36.06 U18.J21
  TOP w0.135: v1(92.43,52.27) 92.43,51.21 R21.1 ; 80.7,36.7 80.7,38.61 80.41,38.89 80.41,40.21 81.15,40.94 81.15,42.5 79.48,44.17 79.25,44.17 77.19,46.23 v1(77.19,46.74)
  L03_SIG1 w0.121: v1(92.43,52.27) 93.03,51.67 105.92,51.67 109.4,55.15 115.45,55.15 J6.11
  BOTTOM w0.135: v1(92.43,52.27) 90.73,52.27 90.3,52.7 82.62,52.7 77.19,47.27 v1(77.19,46.74)
TM4C129_TCK: length 5.1
  TOP w0.135: TP18.1 24.53,40.61 v1(24.43,40.71)
  BOTTOM w0.135: v1(24.43,40.71) 23.53,40.71 21.9,42.33 U37.100
TM4C129_TDI: length 3.8
  TOP w0.135: TP16.1 21.77,39.9 v1(21.77,40.71)
  BOTTOM w0.135: U37.98 21.1,41.38 v1(21.77,40.71)
TM4C129_TDO: length 3.6
  TOP w0.135: v1(20.62,41.71) 20.42,41.5 TP15.1
  BOTTOM w0.135: U37.97 20.7,41.79 v1(20.62,41.71)
TM4C129_TMS: length 4.2
  TOP w0.135: v1(22.91,40.56) 23.16,40.31 TP17.1
  BOTTOM w0.135: v1(22.91,40.56) 21.5,41.97 U37.99
TUSB_ADDR: length 3.9
  TOP w0.135: TP29.1 13.87,28.91 13.55,28.59 U20.5
TUSB_ID: length 3.9
  TOP w0.135: U20.9 10.45,28.99 9.64,29.79 9.02,29.79 TP28.1
TUSB_INT_N: length 2
  TOP w0.135: U20.6 13.45,28.99 14.14,29.68 R110.1
TUSB_OUT1: length 5.6
  TOP w0.135: U15.2 12.57,35.56 12.27,35.26 12.27,33.66 12.83,33.1 13.26,33.1 13.79,32.56 R107.1
TUSB_OUT1_R: length 3.5
  TOP w0.135: R107.2 R106.1 12.34,30.38 11.92,29.96 U20.7
TUSB_OUT2: length 7.3
  TOP w0.135: R104.1 9.45,32.49 11.67,34.7 R92.2 12.37,36.32 12.63,36.06 U15.1
TUSB_OUT2_R: length 3.6
  TOP w0.135: U20.8 11.52,29.67 10.9,30.29 R105.1 R104.2
TYPEC_CC1: length 15
  TOP w0.135: v1(13.46,20.6) 11.52,22.54 U20.1
  TOP w0.254: v1(17.78,18.67) 17.77,18.66 J10.A5
  L03_SIG1 w0.127: v1(17.78,18.67) 17.22,18.11 15.04,18.11 13.46,19.69 v1(13.46,20.6)
TYPEC_CC2: length 18.9
  TOP w0.135: v1(13.51,21.72) 11.92,23.31 U20.2
  L03_SIG1 w0.127: v1(13.51,21.72) 12.55,20.75 12.55,18.46 16.13,14.88 18.46,14.88 J10.B5
TYPEC_DN: length 15.3
  TOP w0.107: v1(19,19.56) 18.64,19.19 18.64,18.65 18.77,18.51 J10.A7
  L03_SIG1 w0.102: J10.B7 18.4,16.72 18.4,16.96 20.17,18.72 20.17,20.19 19.38,20.98 18.9,20.98 18.57,20.65 18.57,19.35 18.67,19.25 18.88,19.25 19,19.38 v1(19,19.56)
  BOTTOM w0.107: L3.2 18.4,22.79 18.09,22.48 18.09,21.99 18.32,21.75 D6.1 18.32,21.27 18.09,21.03 18.09,20.7 18.7,20.09 18.7,19.87 v1(19,19.56)
TYPEC_DP: length 15.3
  TOP w0.107: v1(18.06,19.56) 18.4,19.22 18.4,18.65 18.27,18.51 J10.A6
  L03_SIG1 w0.102: J10.B6 18.66,16.71 18.66,16.85 20.42,18.62 20.42,20.3 19.49,21.23 18.8,21.23 18.31,20.75 18.31,19.81 v1(18.06,19.56)
  BOTTOM w0.107: v1(18.06,19.56) 18.4,19.9 18.4,20.05 17.85,20.6 17.85,21.03 17.62,21.27 D7.1 17.62,21.75 17.85,21.99 17.85,22.48 17.55,22.79 L3.3
UART0_HDR_CTS#: length 54.5
  TOP w0.135: U8.6 109.28,49.18 v1(109.93,49.83)
  L03_SIG1 w0.121: J17.2 153.52,56.41 139.67,56.41 137.05,53.79 116.22,53.79 112.26,49.83 v1(109.93,49.83)
UART0_HDR_RTS#: length 51
  TOP w0.135: U8.12 103.13,47.23 106.73,50.83 v1(107.57,50.83)
  L03_SIG1 w0.121: J17.6 141.4,60.35 137.38,56.33 135.83,56.33 134.14,54.64 111.38,54.64 v1(107.57,50.83)
UART0_HDR_RXD: length 52.7
  TOP w0.135: v1(109.93,47.7) 109.46,47.23 U8.3
  L03_SIG1 w0.121: J17.5 148.33,58.84 141.11,58.84 138.05,55.78 135.81,55.78 134.37,54.33 111.44,54.33 108.25,51.15 108.25,48.36 108.92,47.7 v1(109.93,47.7)
UART0_HDR_TXD: length 55.2
  TOP w0.135: v1(109.32,51.46) 105.94,51.46 103.66,49.18 U8.9
  L03_SIG1 w0.121: J17.4 150.13,58.1 140.85,58.1 136.8,54.04 111.91,54.04 v1(109.32,51.46)
UART1_HDR_CTS#: length 56.4
  TOP w0.135: U12.6 114.27,42.32 v1(114.27,42.32)
  L03_SIG1 w0.121: v1(114.27,42.32) 114.27,42.47 115.77,43.97 115.77,46.22 121.14,51.59 127.36,51.59 127.77,52 136.34,52 136.71,51.64 155.09,51.64 J13.2
UART1_HDR_RTS#: length 51.9
  TOP w0.135: v1(107.49,43.99) 106.6,43.99 102.98,40.37 U12.12
  L03_SIG1 w0.121: v1(107.49,43.99) 116.79,53.29 127.2,53.29 127.66,52.83 136.83,52.83 137.26,52.4 141.07,52.4 142.67,54 J13.6
UART1_HDR_RXD: length 54
  TOP w0.135: U12.3 106.06,40.37 105.56,40.87 105.56,42.42 106.64,43.5 108.14,43.5 v1(108.64,43.99)
  L03_SIG1 w0.121: v1(108.64,43.99) 117.49,52.84 123.2,52.84 123.95,52.1 127.15,52.1 127.56,52.51 136.77,52.51 137.14,52.15 141.38,52.15 142.1,52.87 145.3,52.87 145.59,52.58 148.42,52.58 J13.5
UART1_HDR_TXD: length 56.2
  TOP w0.135: v1(109.78,43.99) 109.22,44.55 105.41,44.55 103.18,42.32 U12.9
  L03_SIG1 w0.121: J13.4 150.27,51.89 136.96,51.89 136.6,52.25 127.66,52.25 127.25,51.84 117.63,51.84 v1(109.78,43.99)
USB0_DN: length 128.3
  TOP w0.102: 87.74,33.74 87.64,33.74 87.63,33.73 87.02,33.73 U18.AA17
  TOP w0.107: v1(95.01,36.07) 94.66,35.72 92.21,35.72 91.47,34.98 89.34,34.98 88.1,33.74 87.74,33.74
  BOTTOM w0.107: L3.1 18.4,25.83 18.09,26.14 18.09,26.44 18.28,26.64 19.56,26.64 22,24.2 29.71,24.2 30.71,25.2 39.44,25.2 40.51,24.13 40.51,20.72 38.89,19.1 38.89,12.14 40,11.02 66.83,11.02 67.53,11.73 75.85,11.73 78.78,14.66 83.35,14.66 85.42,12.6 90.47,12.6 95.94,18.06 95.94,35.53 95.68,35.79 95.29,35.79 v1(95.01,36.07)
USB0_DP: length 128.3
  TOP w0.102: 87.74,33.51 87.73,33.5 87.04,33.5 U18.AA16
  TOP w0.107: 87.74,33.51 88.19,33.51 89.43,34.75 91.57,34.75 92.3,35.48 94.68,35.48 v1(95.01,35.15)
  BOTTOM w0.107: L3.4 17.55,25.83 17.85,26.14 17.85,26.54 18.19,26.87 19.66,26.87 22.1,24.43 29.62,24.43 30.62,25.44 39.54,25.44 40.74,24.23 40.74,20.62 39.12,19 39.12,12.24 40.1,11.26 66.73,11.26 67.44,11.96 75.75,11.96 78.68,14.9 83.45,14.9 85.52,12.83 90.38,12.83 95.7,18.16 95.7,35.44 95.58,35.56 95.02,35.56 94.89,35.43 94.89,35.28 v1(95.01,35.15)
USB0_DRVVBUS: length 7
  TOP w0.102: U18.B19 76.34,34.86 76.16,35.03
  TOP w0.135: TP21.1 72.65,35.86 73.96,35.86 74.29,36.19 75,36.19 76.16,35.03
USB0_ID: length 15
  TOP w0.102: U18.Y17 86.67,34.14 87.49,34.14 87.74,34.39
  TOP w0.135: 87.74,34.39 90,36.65 91.87,36.65 92.3,36.22 93.42,36.22 94.03,36.83 97.36,36.83 98.63,38.1 R83.2
USB0_RCALIB: length 2.6
  TOP w0.102: v2(85.93,34.33) 85.89,34.3 U18.W17
  BOTTOM w0.135: v2(85.93,34.33) 86.44,34.84 86.44,35.47 86.97,36 R239.1
USB0_VBUS: length 154.7
  TOP w0.102: v2(85.93,34.89) U18.V18
  TOP w0.381: v1(39.27,26.01) R116.2 39.27,26.79 R118.2
  L03_SIG1 w0.254: v1(103.38,41.86) 103.38,40.89 102.11,39.62 99.74,39.62 99.56,39.8 90.4,39.8 85.93,35.33 v2(85.93,34.89) ; v1(38.98,61.84) 75.02,61.84 78.51,58.35 83.32,58.35 85.48,60.5 100.56,60.5 101.42,59.64 v1(101.42,59.13)
  BOTTOM w0.254: v1(103.38,41.86) 108.06,46.54 108.06,51.03 105.7,53.39 103.63,53.39 102.62,54.4 102.62,57.94 v1(101.42,59.13) ; v1(39.27,26.01) 41.1,27.84 41.1,38.96 35.55,44.52 35.55,46.47 40.01,50.93 40.01,52.45 38.15,54.31 38.15,61.01 v1(38.98,61.84)
USBC_SHIELD:
  vias: v1(13.34,13.59) v1(13.34,12.32) v1(14.61,13.59) v1(14.61,12.32) v1(15.88,13.59) v1(15.88,12.32) v1(22.99,13.59) v1(22.99,12.32) v1(24.26,13.59) v1(24.26,12.32) v1(25.53,12.32) v1(26.8,12.32)
USER_INTN: length 29
  TOP w0.102: 76.05,29.67 76.16,29.67 76.23,29.73 76.25,29.73 76.31,29.8 76.33,29.8 76.67,30.14 77.11,30.14 U18.B9
  TOP w0.135: v1(63.98,30.13) 65.6,30.13 67.13,28.6 68.83,28.6 68.94,28.7 69.01,28.77 69.02,28.79 70.85,28.79 70.97,28.91 73.76,28.91 74.52,29.67 76.05,29.67 ; v1(62.08,38.71) 62.15,38.79 62.15,40.14 TP12.1 60.46,40.82 60.26,41.01 U13.5
  BOTTOM w0.135: v1(62.08,38.71) 64.3,36.49 64.3,30.45 v1(63.98,30.13)
USER_LED1: length 139.6
  TOP w0.102: U18.W20 85.91,35.38 85.91,36.06 86.29,36.44 86.53,36.44 86.54,36.46 86.57,36.46 86.82,36.7
  TOP w0.135: v1(5,50.8) 5.71,50.09 5.71,47.96 5.3,47.54 R38.2 3.98,47.54 3.5,47.05 Q2.3 ; 86.82,36.7 86.82,36.73 87.81,37.72 87.81,39.07 88.98,40.23 90.35,40.23 91.72,41.61 94.03,41.61 95.81,43.38 v1(95.81,43.87) 95.81,44.84 R61.1
  L03_SIG1 w0.121: v1(5,50.8) 11.76,57.56 13.54,57.56 16.48,60.49 23.59,60.49 24.13,59.95 28.49,59.95 29.02,59.42 36.19,59.42 37.55,60.78 74.72,60.78 79.83,55.68 83.55,55.68 84.28,54.94 96.22,54.94 96.67,54.49 98.93,54.49 v1(99.24,54.18)
  BOTTOM w0.135: v1(95.81,43.87) 96.39,43.87 96.9,44.37 99.89,44.37 101.25,45.74 101.25,49.83 100.56,50.52 100.56,51.89 99.24,53.21 v1(99.24,54.18)
USER_LED2: length 138.2
  TOP w0.102: 87.2,36.7 86.73,36.24 86.37,36.24 86.11,35.98 86.11,35.64 U18.Y20
  TOP w0.135: 87.2,36.7 91.8,41.3 94.2,41.3 96.76,43.87 v1(97.33,43.87) 97.34,43.87 R62.1 ; Q1.3 R14.2 v1(4.57,52.43)
  L03_SIG1 w0.121: v1(100.1,54.51) 99.76,54.85 97.1,54.85 96.74,55.2 84.39,55.2 83.59,56.01 79.86,56.01 74.83,61.03 37.44,61.03 36.08,59.67 31.31,59.67 29.87,61.11 26.82,61.11 24.69,63.25 22.05,63.25 22.02,63.25 21.83,63.25 21.8,63.25 15.82,63.25 8.76,56.18 7.32,56.18 4.57,53.44 v1(4.57,52.43)
  BOTTOM w0.135: v1(100.1,54.51) 100.1,52.88 100.83,52.16 100.83,50.68 101.52,49.99 101.52,45.52 99.87,43.87 v1(97.33,43.87)
VMON_MRN: length 21.1
  TOP w0.135: v1(10.44,61.62) SW1.1 11.65,62.68 12.4,63.42 14.43,63.42 15.05,62.8 15.05,62.8 15.17,62.68 SW1.3
  BOTTOM w0.135: Q8.6 10.97,60.34 10.44,60.88 v1(10.44,61.62) ; Q8.6 Q8.5 ; Q8.6 12.07,60.34 Q8.8 12.72,60.34 Q8.1 Q8.2 14.27,59.69 14.63,59.33 14.63,57.99 15.74,56.88 U27.1
  BOTTOM w0.152: R171.1 D5.1 9.75,62.42 9.81,62.36 C79.1 10.44,62.34 v1(10.44,61.62)
VMON_VSYS: length 28.8
  TOP w0.102: U18.G13 79.46,31.86 v2(79.42,31.9)
  L03_SIG1 w0.102: v2(79.42,31.9) 78.87,32.46 78.87,32.98 78.59,33.26 77.71,33.26 77.48,33.03 77.29,33.03
  L03_SIG1 w0.203: 77.29,33.03 77.28,33.02 74.6,33.02 73.89,32.31 70.89,32.31 69.33,30.75 68.21,30.75 67.76,31.2 67.76,33.05 v1(66.57,34.24)
  BOTTOM w0.203: C232.1 64.74,32.41 v1(66.57,34.24)
  BOTTOM w0.33: C232.1 64.58,26.82 R255.1
  BOTTOM w0.508: R262.2 R255.1
VPP_1V8: length 28.5
  TOP w0.203: 54,39.27 54,39.27 U14.5
  TOP w0.254: 54.86,38.91 C38.1 57.15,38.91 58.75,37.31 v1(58.75,36.68) ; 54.86,38.91 54.2,38.91 U14.5 ; 54.86,38.91 54.86,38.91
  TOP w0.33: v2(78.9,33.82) 78.89,33.82 U18.E16
  L03_SIG1 w0.254: v2(78.9,33.82) 73.62,33.82 73.05,34.39 69.37,34.39 69.01,34.75 64.29,34.75 62.36,36.68 v1(58.75,36.68)
VPP_1V8_REG_EN: length 119.7
  TOP w0.102: U18.Y13 86.67,31.58 87.01,31.58 87.13,31.7 87.74,31.7
  TOP w0.135: v1(98.73,34.09) 97.59,34.09 95.2,31.7 87.74,31.7
  TOP w0.33: U14.3 50.18,36.82 49.6,36.24 R90.2 v1(49.07,35.48)
  L03_SIG1 w0.121: v1(58.32,53.87) 63.73,53.87 65.3,55.45 68.81,55.45 69.32,54.94 72.65,54.94 73.18,54.41 78.46,54.41 78.83,54.77 83.32,54.77 83.96,54.13 87.71,54.13 88.31,53.52 90.28,53.52 90.58,53.82 95.99,53.82 96.64,53.17 102.22,53.17 v1(103.38,54.33)
  BOTTOM w0.135: v1(49.07,35.48) 55.63,42.04 55.63,51.18 v1(58.32,53.87)
  BOTTOM w0.178: v1(103.38,54.33) 107.09,54.33 110.38,51.04 110.38,40.57 108.29,38.48 103.12,38.48 v1(98.73,34.09)
VSYS_3V3: length 253.3
  TOP w0.254: U19.18 C46.1 C43.1 140.18,36.32 v1(140.16,36.35) ; U22.10 159.06,24.77 159.44,25.15 C59.1 v1(159.87,24.54) ; U7.18 C7.1 C6.1 140.18,55.37 v1(140.16,55.4) ; U4.24 31.84,52.72 32.13,53.01 ; R80.1 45.54,39.75 46.36,40.56 54.1,40.56 56.58,43.04 v1(56.58,45.52) ; R89.2 64.4,38.08 64.19,37.86 64.19,37.31 63.93,37.06 C41.1 ; U16.3 C45.1 33.28,34.64 v1(33.35,34.57) ; R5.2 v1(71.06,58.2) ; U13.8 58.76,43.09 C29.1 ; U19.30 135.01,29.28 134.51,29.78 C54.1 133.98,30.34 v1(133.99,30.35) ; 33.5,51.82 33.34,51.65 U4.23 ; U7.30 135.01,48.33 134.51,48.83 C14.1 133.98,49.34 v1(133.91,49.4) ; U16.6 26.62,34.64 v1(26.57,34.7) ; U5.6 58.41,48.25 C15.1 58.03,48.23 v1(57.85,48.06)
  TOP w0.305: v1(50.78,47.62) 51.03,47.37 C21.1 ; U17.8 63.39,36.8 C41.1
  TOP w0.33: U2.2 82.27,48.01 82.78,48.51 82.78,48.77 83.2,49.2 C12.1 83.21,50.35 C10.1 ; v1(99.84,45.37) C24.1 U8.14 ; C6.1 v1(139.54,54.31) ; v1(115.95,48.13) 115.95,48.14 R32.2 ; v1(126.83,49.45) C13.1 C16.2 126.29,48.01 126.19,48.11 ; v1(84.76,49.2) 84.51,48.95 R37.2 ; C29.1 v1(58.17,43.1) ; C8.1 34.87,53.09 v1(34.77,53.19) ; v1(111.98,52.51) C9.2 U3.4 ; v1(99.84,38.49) C37.1 U12.14 ; v1(52.05,47.62) 51.92,47.5 C22.1 ; U25.1 68.09,16.37 68.33,16.13 C74.1 67.95,15.62 67.61,15.29 v1(67.61,15.19) ; C43.1 v1(139.54,35.26)
  TOP w0.381: v1(139.54,35.26) 139.49,35.31 R95.1 ; R1.2 18.52,60.06 v1(18.52,60.07) ; v1(99.82,17.55) 99.82,14.18 100.5,13.5 R163.1 ; 10.59,43.64 10.37,43.86 U9.1 ; 126.19,48.11 126.11,48.19 U6.6 ; v1(34.3,58.6) 34.29,58.6 34.28,58.59 R3.2 ; v1(98.27,42.09) 98.25,42.09 97.57,42.76 R588.2 ; v1(67.13,38.68) 67.31,38.51 R82.1 ; v1(69.55,49.86) 69.03,49.35 R36.2 ; R88.1 66.6,37.11 65.63,38.08 R89.2 ; R590.2 92.61,39.08 91.99,38.46 v1(91.77,38.46) ; R10.2 84.24,56.61 84.25,56.62 v1(84.33,56.62) ; v1(65.1,8.43) 65.13,8.43 65.43,8.74 R164.2 ; R112.2 v1(44.17,36.81) ; R4.2 v1(25.58,58.57)
  TOP w0.508: R44.2 95.81,48.89 v1(95.81,48.9) ; R136.1 141.66,21.7 141.66,21.69 v1(141.66,21.62) ; R41.2 89.67,48.19 89.66,48.18 v1(89.51,48.18) 89.5,48.19 R40.2 ; R7.1 2.57,56.69 v1(2.57,56.69) ; v1(64.94,38.79) 64.94,38.15 R89.2 ; v1(142.23,16.52) 139.14,13.44 v1(139.14,12.47) ; C10.1 v1(83.23,51.3) ; R43.2 94.29,48.87 v1(94.31,48.9) ; R135.1 140.19,21.7 140.18,21.69 v1(140.18,21.62) ; R18.1 2.57,50.59 v1(2.57,50.6) ; R91.1 5.55,37.35 5.18,37.72 v1(5.16,37.72) ; R134.1 v1(136.22,21.64) ; C40.1 R80.1 ; v1(135.89,40.71) 135.89,40.72 136.22,41.05 R73.1 ; R79.1 v1(7.01,40.77) ; R45.2 97.34,48.87 v1(97.33,48.87) ; v1(86.99,49.21) 87.13,49.07 R39.2 ; 49.64,50.04 49.36,49.77 R35.1 49.36,47.64 49.64,47.37 C27.1 ; R68.1 v1(132.21,43.74) ; R129.1 v1(132.21,24.69) ; R12.1 v1(135.95,54.49)
  L03_SIG1 w0.254: v1(67.61,15.19) 67.61,20.78 v1(68.58,21.74)
  L04_PWR1 w0.508: v1(67.61,15.19) 66.45,14.02 66.45,12.5 65.61,11.66 ; v1(33.35,34.57) 30.63,34.57 ; v1(99.82,17.55) 99.82,20.47
  L05_GND2 w0.508: v1(142.23,16.52) 142.23,19.62 v1(143.31,20.7)
  BOTTOM w0.135: 132.99,45.87 v1(132.99,45.89)
  BOTTOM w0.178: C259.1 U42.1
  BOTTOM w0.203: C218.1 120.88,29.36 ; C122.1 120.88,39.98 ; U33.5 122.15,42.78 121.97,42.95 ; U39.4 121.14,31.29 ; C219.1 119.87,29.36
  BOTTOM w0.254: U40.17 109.71,25.33 110.92,25.33 C248.1 v1(111.17,24.51) ; U40.1 C166.1 v1(111.55,33.91) ; C93.1 133.99,49.32 v1(133.91,49.4) ; U30.10 C90.1 96.96,52.12 v1(96.95,52.12) ; R168.1 R169.1 v1(179.37,59.79) ; v1(112.7,29.77) 112.64,29.71 110.58,29.71 110.46,29.84 U40.8 ; v1(103.64,28.79) 103.63,28.8 C209.1 104.4,29.54 104.6,29.34 U40.30 ; U46.2 140.24,12.47 140.24,12.47 C270.1 v1(139.14,12.47) ; U46.8 v1(142.23,16.52)
  BOTTOM w0.33: v1(116.32,45.26) 116.36,45.26 116.36,45.27 C103.1 U32.1 ; v1(168.05,16.46) C265.2 166.15,16.46 165.82,16.79 U44.5 ; U43.5 140.92,20.93 C258.1 143.08,20.93 v1(143.31,20.7) 143.31,20.09 143.06,19.84 R275.2 ; v1(68.58,21.74) 68.83,21.49 C259.1 ; v1(133.99,30.35) 133.98,30.34 C54.1 ; 159.1,42.54 159.13,42.57 C112.2 160.15,42.57 160.15,42.57 v1(160.21,42.57) ; U34.5 140.35,40.16 140.68,39.83 C119.1 v1(142.77,39.83) 142.77,39.22 142.44,38.89 R236.2 ; v1(75.13,48.26) 75.46,47.93 C94.1 U31.5 ; U29.5 127.9,51.42 128.14,51.66 128.14,52.78 C87.1 128.14,53.34 v1(128.14,53.37) ; C86.1 C84.1 ; C152.1 140.21,36.3 v1(140.16,36.35) ; C152.1 140.16,35.52 C159.1 ; C152.1 139.85,35.56 v1(139.54,35.26) ; v1(126.82,44.72) 126.82,44.73 C106.1 U32.24
  BOTTOM w0.381: R230.1 133.85,41.39 v1(133.93,41.48) ; v1(45.58,50.46) 43.64,48.52 43.64,42.39 43.3,42.06 R224.2 ; v1(142.47,22.43) 142.48,22.42 R266.1 ; R268.1 v1(135.47,22.42) ; R269.1 v1(133.94,22.42) ; v1(139.54,54.31) 139.85,54.61 C84.1 ; v1(144.02,41.48) 143.94,41.48 143.93,41.47 R226.1 ; R254.1 132.99,26.82 v1(132.99,26.85) 132.13,26.85 131.73,27.25 131.73,29.95 132.13,30.35 v1(133.99,30.35) ; R229.1 135.37,41.39 v1(135.46,41.48) ; v1(21.23,47.12) 22.28,48.17 R201.2 ; v1(146.18,41.48) 146.17,41.47 R225.1 ; R265.1 v1(145.51,22.42) ; R170.2 v1(27.61,59.36) ; R218.1 132.99,45.87 ; R264.1 v1(147.34,22.42) ; 159.1,42.54 U35.1 ; R210.1 v1(166.9,54.28) ; R258.1 v1(167.03,33.71) ; U34.5 141.35,41.47 R227.1
  BOTTOM w0.508: R183.2 v1(79.78,54.03) ; FB3.1 71.83,38.4 v1(70.97,39.27) ; R237.1 R238.1 65.45,38.01 64.94,38.51 v1(64.94,38.79) ; v1(44.17,36.81) 44.17,39.6 42.55,41.22 R224.2 ; R223.2 v1(161.34,38.44) ; R220.2 v1(161.34,41.53) ; R252.2 v1(157,31.93) ; R282.1 v1(182.88,11.84) ; R285.1 v1(178.38,11.84) ; v1(91.82,36.09) 91.25,35.52 FB4.1 v1(92.74,34.9) ; R166.1 177.17,62.04 v1(177.16,62.05) 177.16,62.04 R167.1 ; R181.2 v1(75.16,55.38) ; R257.2 v1(157,28.63) ; R283.1 v1(181.38,11.84) ; R284.1 v1(179.88,11.84)
  vias: v1(9.63,41.96) v1(10.49,42.8) v1(33.5,53.19) v1(35.71,12.19) v1(36.98,12.19) v1(50.78,50.16) v1(50.78,48.9) v1(52.05,50.16) v1(52.05,48.9) v1(53.32,50.16) v1(53.32,48.9) v1(53.32,47.62) v1(54.59,50.16) v1(54.59,48.9) v1(54.59,47.62) v1(56.58,48.06) v1(56.58,46.79) v1(57.85,46.79) v1(57.85,45.52) v1(59.12,46.79) v1(59.12,45.52) v1(88.87,21.56) v1(89.51,21.97) v1(99.09,59.54) v1(100.36,59.54) v1(100.36,58.27) v1(116.59,42.42) v1(116.59,41.15) v1(116.59,39.88) v1(116.59,31.7) v1(116.59,30.43) v1(116.59,29.16) v1(117.86,42.42) v1(117.86,41.15) v1(117.86,39.88) v1(117.86,31.7) v1(117.86,30.43) v1(117.86,29.16)
VSYS_3V3_CT: length 2.7
  BOTTOM w0.254: C81.1 17.24,58.7 U27.4
VSYS_3V3_FB: length 4.4
  TOP w0.254: U10.2 43.93,42.61 43.92,42.61 43.92,41.17 R77.1 R80.2 C40.2
VSYS_3V3_R: length 3.9
  TOP w0.508: C26.1 47.6,47.6 48.38,48.38 R35.2 48.38,49.89 48.11,50.16
VSYS_3V3_SENSE: length 6.2
  BOTTOM w0.135: R201.1 R195.1 21.3,50.48 20.35,51.44 20.35,53.04 19.8,53.58 U27.9
VSYS_3V3_SW: length 4.8
  TOP w0.254: U10.6 44.43,45.08 44.85,45.51
  TOP w0.762: 44.85,45.51 L1.1
VSYS_5V0: length 99.6
  TOP w0.254: U10.7 43.93,45.64 C25.1 ; C51.1 49.64,30.4 U21.7 ; U23.8 32.7,23.69 32.72,23.7 ; U23.7 32.78,23.19
  TOP w0.305: 122.6,43.45 122.17,43.02 C123.1 121.56,42.47 v1(121.36,42.27)
  TOP w0.381: R85.2 41.7,37.99 41.67,37.99 v1(41.63,37.95) ; R117.1 34.97,24.99 v1(34.54,24.56) ; v1(16.54,49.48) 17.11,48.9 17.11,41.17 15.57,39.62 12.7,39.62 11.68,40.64 8.64,40.64 6.73,38.73 R86.1 ; R161.2 v1(100.5,15.2) ; R11.1 v1(12.05,55.71)
  TOP w0.508: U14.1 50.36,38.72 49.94,39.14
  TOP w0.762: J9.1 137.27,15.11 131.34,21.03 129.08,21.03 127.36,22.76 127.36,40.41 124.32,43.45 122.6,43.45
  BOTTOM w0.203: U33.4 121.62,42.01 v1(121.36,42.27)
  BOTTOM w0.254: U27.14 16.24,51.05 16.38,50.91 C91.1 16.38,49.63 v1(16.54,49.48) ; U46.15 146.26,12.47 C269.1 v1(146.89,12.47)
  BOTTOM w0.33: v1(65.53,23.24) 65.56,23.27 R262.1 ; v1(163.42,22.66) R270.1 v1(164.19,23.46)
  BOTTOM w0.381: R171.2 9.28,58.49 v1(12.05,55.71) ; R211.2 12.07,47.24 12.36,47.53 13.09,47.53 13.64,48.08 15.14,48.08 v1(16.54,49.48) ; v1(23.27,52.11) 23.2,52.04 R188.1
  BOTTOM w0.508: R272.1 v1(156.51,20.73) ; R274.1 v1(152.98,20.73) ; R281.1 v1(152.98,14.38) ; R273.1 v1(154.79,20.73) ; R279.1 v1(156.51,14.38) ; R280.1 v1(154.79,14.38)
  vias: v1(32.26,24.59) v1(33.27,24.56) v1(33.27,23.6) v1(34.54,23.6) v1(35.89,24.56) v1(35.89,23.6) v1(35.92,22.66) v1(37.16,24.56) v1(37.16,23.6) v1(37.19,22.66) v1(39.98,48.64) v1(39.98,47.37) v1(39.98,46.1) v1(39.98,44.83) v1(41.25,48.64) v1(41.25,47.37) v1(41.25,46.1) v1(41.25,44.83) v1(42.52,48.64) v1(42.52,47.37) v1(42.52,46.1) v1(42.52,44.83) v1(45.7,33.35) v1(45.7,32.08) v1(45.7,30.81) v1(45.7,29.54) v1(46.84,37.03) v1(46.89,39.57) v1(46.89,38.3) v1(46.97,33.35) v1(46.97,32.08) v1(46.97,30.81) v1(46.97,29.54) v1(48.16,39.57) v1(48.24,33.35) v1(48.24,32.08) v1(48.24,30.81) v1(48.24,29.54)
