# Allegro board PROC109E2_BRD.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
LED_150040GS73220_40X20_SMD_0-4
  rect 0.406x0.457 smd: 1(-0.5,0) 2(0.5,0)
LED_150060SS75000_70X40_SMD_0-8
  rect 0.787x0.787 smd: 1(-0.8,0) 2(0.8,0)
MSOP10_19-68_120X120_1-1
  rect 1.448x0.305 smd: 1(-2.2,1) 2(-2.2,0.5) 3(-2.2,0) 4(-2.2,-0.5) 5(-2.2,-1) 6(2.2,-1) 7(2.2,-0.5) 8(2.2,0) 9(2.2,0.5) 10(2.2,1)
OSC4_ASEK_130X100_SMD_1-2
  rect 1.397x0.991 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
QFN16_19-68_120X120_1_EP1-6
  rect 0.838x0.254 smd: 1(-1.45,0.75) 2(-1.45,0.25) 3(-1.45,-0.25) 4(-1.45,-0.75) 9(1.45,-0.75) 10(1.45,-0.25) 11(1.45,0.25) 12(1.45,0.75)
  rect 0.254x0.838 smd: 5(-0.75,-1.45) 6(-0.25,-1.45) 7(0.25,-1.45) 8(0.75,-1.45) 13(0.75,1.45) 14(0.25,1.45) 15(-0.25,1.45) 16(-0.75,1.45)
  rect 1.6x1.6 smd: 17(0,0)
QFN16_19-68_160X140_1
  rect 0.864x0.279 smd: 1(-1.975,-0.75) 8(1.975,-0.75) 9(1.975,0.75) 16(-1.975,0.75)
  rect 0.279x0.864 smd: 2(-1.25,-1.725) 3(-0.75,-1.725) 4(-0.25,-1.725) 5(0.25,-1.725) 6(0.75,-1.725) 7(1.25,-1.725) 10(1.25,1.725) 11(0.75,1.725) 12(0.25,1.725) 13(-0.25,1.725) 14(-0.75,1.725) 15(-1.25,1.725)
  rect 2.54x2.057 smd: 17(0,0)
QFN20_19-68_160X160_1
  rect 0.889x0.305 smd: 1(-2.05,1) 2(-2.05,0.5) 3(-2.05,0) 4(-2.05,-0.5) 5(-2.05,-1) 11(2.05,-1) 12(2.05,-0.5) 13(2.05,0) 14(2.05,0.5) 15(2.05,1)
  rect 0.305x0.889 smd: 6(-1,-2.05) 7(-0.5,-2.05) 8(0,-2.05) 9(0.5,-2.05) 10(1,-2.05) 16(1,2.05) 17(0.5,2.05) 18(0,2.05) 19(-0.5,2.05) 20(-1,2.05)
  rect 2.794x2.794 smd: 21(0,0)
QFN24_19-68_220X140_1
  rect 0.838x0.279 smd: 1(-2.725,-0.75) 12(2.725,-0.75) 13(2.725,0.75) 24(-2.725,0.75)
  rect 0.279x0.838 smd: 2(-2.25,-1.725) 3(-1.75,-1.725) 4(-1.25,-1.725) 5(-0.75,-1.725) 6(-0.25,-1.725) 7(0.25,-1.725) 8(0.75,-1.725) 9(1.25,-1.725) 10(1.75,-1.725) 11(2.25,-1.725) 14(2.25,1.725) 15(1.75,1.725) 16(1.25,1.725) 17(0.75,1.725) 18(0.25,1.725) 19(-0.25,1.725) 20(-0.75,1.725) 21(-1.25,1.725) 22(-1.75,1.725) 23(-2.25,1.725)
  custom 0.508x0.508 smd: 25(0,0)
QFN48_19-68_280X280_1_EP4-2
  rect 0.838x0.305 smd: 1(-3.5,2.75) 2(-3.5,2.25) 3(-3.5,1.75) 4(-3.5,1.25) 5(-3.5,0.75) 6(-3.5,0.25) 7(-3.5,-0.25) 8(-3.5,-0.75) 9(-3.5,-1.25) 10(-3.5,-1.75) 11(-3.5,-2.25) 12(-3.5,-2.75) 25(3.5,-2.75) 26(3.5,-2.25) 27(3.5,-1.75) 28(3.5,-1.25) 29(3.5,-0.75) 30(3.5,-0.25) 31(3.5,0.25) 32(3.5,0.75) 33(3.5,1.25) 34(3.5,1.75) 35(3.5,2.25) 36(3.5,2.75)
  rect 0.305x0.838 smd: 13(-2.75,-3.5) 14(-2.25,-3.5) 15(-1.75,-3.5) 16(-1.25,-3.5) 17(-0.75,-3.5) 18(-0.25,-3.5) 19(0.25,-3.5) 20(0.75,-3.5) 21(1.25,-3.5) 22(1.75,-3.5) 23(2.25,-3.5) 24(2.75,-3.5) 37(2.75,3.5) 38(2.25,3.5) 39(1.75,3.5) 40(1.25,3.5) 41(0.75,3.5) 42(0.25,3.5) 43(-0.25,3.5) 44(-0.75,3.5) 45(-1.25,3.5) 46(-1.75,3.5) 47(-2.25,3.5) 48(-2.75,3.5)
  rect 4.191x4.191 smd: 49(0,0)
RECPT_2X10_CRD-081413-A_S_T_8-6
  rect 1.88x1.88 hole 1.168: 1(0,0)
  round 1.88 hole 1.168: 2(0,-2.54) 3(2.54,0) 4(2.54,-2.54) 5(5.08,0) 6(5.08,-2.54) 7(7.62,0) 8(7.62,-2.54) 9(10.16,0) 10(10.16,-2.54) 11(12.7,0) 12(12.7,-2.54) 13(15.24,0) 14(15.24,-2.54) 15(17.78,0) 16(17.78,-2.54) 17(20.32,0) 18(20.32,-2.54) 19(22.86,0) 20(22.86,-2.54)
RES0201_0-5
  rect 0.457x0.432 smd: 1(-0.33,0) 2(0.33,0)
RES0402_0-5
  rect 0.559x0.635 smd: 1(-0.49,0) 2(0.49,0)
RES0406_0-5
  rect 0.559x1.753 smd: 1(-0.49,0) 2(0.49,0)
RES0603_0-75
  rect 0.635x0.991 smd: 1(-0.74,0) 2(0.74,0)
SC70-5
  rect 0.762x0.406 smd: 1(-1,0.65) 2(-1,0) 3(-1,-0.65) 4(1,-0.65) 5(1,0.65)
SC70-5_1-1
  rect 0.94x0.406 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0.65)
SC70-6
  rect 0.94x0.406 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0) 6(1.1,0.65)
SOIC16_1-8
  rect 1.549x0.61 smd: 1(-2.7,4.445) 2(-2.7,3.175) 3(-2.7,1.905) 4(-2.7,0.635) 5(-2.7,-0.635) 6(-2.7,-1.905) 7(-2.7,-3.175) 8(-2.7,-4.445) 9(2.7,-4.445) 10(2.7,-3.175) 11(2.7,-1.905) 12(2.7,-0.635) 13(2.7,0.635) 14(2.7,1.905) 15(2.7,3.175) 16(2.7,4.445)
SOIC16_W_2-7
  rect 2.007x0.61 smd: 1(-4.65,4.445) 2(-4.65,3.175) 3(-4.65,1.905) 4(-4.65,0.635) 5(-4.65,-0.635) 6(-4.65,-1.905) 7(-4.65,-3.175) 8(-4.65,-4.445) 9(4.65,-4.445) 10(4.65,-3.175) 11(4.65,-1.905) 12(4.65,-0.635) 13(4.65,0.635) 14(4.65,1.905) 15(4.65,3.175) 16(4.65,4.445)
SON6_25-59_85X85_0-8
  rect 0.61x0.356 smd: 1(-1.05,0.65) 2(-1.05,0) 3(-1.05,-0.65) 4(1.05,-0.65) 5(1.05,0) 6(1.05,0.65)
  rect 1.092x1.702 smd: 7(0,0)
SON6_CSD17313Q2_80X80
  rect 0.406x0.457 smd: 1(-0.65,-0.922) 2(0,-0.922) 3(0.65,-0.922) 4(0.65,0.922) 5(0,0.922) 6(-0.65,0.922)
  rect 0.406x0.864 smd: 7(0.65,0.096)
  rect 1.041x1.092 smd: 8(-0.325,0)
SON8_25-59_130X130_1
  rect 0.762x0.356 smd: 1(-1.45,0.975) 2(-1.45,0.325) 3(-1.45,-0.325) 4(-1.45,-0.975) 5(1.45,-0.975) 6(1.45,-0.325) 7(1.45,0.325) 8(1.45,0.975)
  rect 1.753x2.515 smd: 9(0,0)
SOT23-5
  rect 1.092x0.61 smd: 1(-1.3,0.95) 2(-1.3,0) 3(-1.3,-0.95) 4(1.3,-0.95) 5(1.3,0.95)
SOT23-5_1-5
  rect 1.295x0.66 smd: 1(-1.4,0.95) 2(-1.4,0) 3(-1.4,-0.95) 4(1.4,-0.95) 5(1.4,0.95)
SOT23-5_1-5#2
  rect 1.092x0.61 smd: 1(-1.3,0.95) 2(-1.3,0) 3(-1.3,-0.95) 4(1.3,-0.95) 5(1.3,0.95)
SOT23-123_1-2
  rect 1.016x0.61 smd: 1(-1.15,0.95) 2(-1.15,-0.95) 3(1.15,0)
SOT553-5_0-6
  rect 0.762x0.305 smd: 1(-0.79,0.5) 2(-0.79,0) 3(-0.79,-0.5) 4(0.79,-0.5) 5(0.79,0.5)
SW4_436331045822_190X190_SMD_1-7
  round 0.686 hole 0.813 unplated: (0,1.375) (0,-1.375)
  rect 1.194x0.991 smd: 1(2.8,0.85) 2(2.8,-0.85) 3(-2.8,0.85) 4(-2.8,-0.85)
SW16_416131160808_460X230_SMD_2-7
  rect 0.762x1.27 smd: 1(-4.445,-3.81) 2(-3.175,-3.81) 3(-1.905,-3.81) 4(-0.635,-3.81) 5(0.635,-3.81) 6(1.905,-3.81) 7(3.175,-3.81) 8(4.445,-3.81) 9(4.445,3.81) 10(3.175,3.81) 11(1.905,3.81) 12(0.635,3.81) 13(-0.635,3.81) 14(-1.905,3.81) 15(-3.175,3.81) 16(-4.445,3.81)
TP20_SMD
  round 0.508 smd: 1(0,0)
TP40_SMD
  round 1.016 smd: 1(0,0)
TP_40X65
  round 1.651 hole 1.016: 1(0,0)
TQFN42_19-68_140X360_0-8
  rect 0.838x0.305 smd: 1(-1.7,4) 2(-1.7,3.5) 3(-1.7,3) 4(-1.7,2.5) 5(-1.7,2) 6(-1.7,1.5) 7(-1.7,1) 8(-1.7,0.5) 9(-1.7,0) 10(-1.7,-0.5) 11(-1.7,-1) 12(-1.7,-1.5) 13(-1.7,-2) 14(-1.7,-2.5) 15(-1.7,-3) 16(-1.7,-3.5) 17(-1.7,-4) 22(1.7,-4) 23(1.7,-3.5) 24(1.7,-3) 25(1.7,-2.5) 26(1.7,-2) 27(1.7,-1.5) 28(1.7,-1) 29(1.7,-0.5) 30(1.7,0) 31(1.7,0.5) 32(1.7,1) 33(1.7,1.5) 34(1.7,2) 35(1.7,2.5) 36(1.7,3) 37(1.7,3.5) 38(1.7,4)
  rect 0.305x0.838 smd: 18(-0.75,-4.45) 19(-0.25,-4.45) 20(0.25,-4.45) 21(0.75,-4.45) 39(0.75,4.45) 40(0.25,4.45) 41(-0.25,4.45) 42(-0.75,4.45)
  rect 2.159x7.645 smd: 43(0,0)
TQFP128_15-74_550X550_1-2
  rect 1.499x0.203 smd: 1(-7.7,6.2) 2(-7.7,5.8) 3(-7.7,5.4) 4(-7.7,5) 5(-7.7,4.6) 6(-7.7,4.2) 7(-7.7,3.8) 8(-7.7,3.4) 9(-7.7,3) 10(-7.7,2.6) 11(-7.7,2.2) 12(-7.7,1.8) 13(-7.7,1.4) 14(-7.7,1) 15(-7.7,0.6) 16(-7.7,0.2) 17(-7.7,-0.2) 18(-7.7,-0.6) 19(-7.7,-1) 20(-7.7,-1.4) 21(-7.7,-1.8) 22(-7.7,-2.2) 23(-7.7,-2.6) 24(-7.7,-3) 25(-7.7,-3.4) 26(-7.7,-3.8) 27(-7.7,-4.2) 28(-7.7,-4.6) 29(-7.7,-5) 30(-7.7,-5.4) 31(-7.7,-5.8) 32(-7.7,-6.2) 65(7.7,-6.2) 66(7.7,-5.8) 67(7.7,-5.4) 68(7.7,-5) 69(7.7,-4.6) 70(7.7,-4.2) 71(7.7,-3.8) 72(7.7,-3.4) 73(7.7,-3) 74(7.7,-2.6) 75(7.7,-2.2) 76(7.7,-1.8) 77(7.7,-1.4) 78(7.7,-1) 79(7.7,-0.6) 80(7.7,-0.2) 81(7.7,0.2) 82(7.7,0.6) 83(7.7,1) 84(7.7,1.4) 85(7.7,1.8) 86(7.7,2.2) 87(7.7,2.6) 88(7.7,3) 89(7.7,3.4) 90(7.7,3.8) 91(7.7,4.2) 92(7.7,4.6) 93(7.7,5) 94(7.7,5.4) 95(7.7,5.8) 96(7.7,6.2)
  rect 0.203x1.499 smd: 33(-6.2,-7.7) 34(-5.8,-7.7) 35(-5.4,-7.7) 36(-5,-7.7) 37(-4.6,-7.7) 38(-4.2,-7.7) 39(-3.8,-7.7) 40(-3.4,-7.7) 41(-3,-7.7) 42(-2.6,-7.7) 43(-2.2,-7.7) 44(-1.8,-7.7) 45(-1.4,-7.7) 46(-1,-7.7) 47(-0.6,-7.7) 48(-0.2,-7.7) 49(0.2,-7.7) 50(0.6,-7.7) 51(1,-7.7) 52(1.4,-7.7) 53(1.8,-7.7) 54(2.2,-7.7) 55(2.6,-7.7) 56(3,-7.7) 57(3.4,-7.7) 58(3.8,-7.7) 59(4.2,-7.7) 60(4.6,-7.7) 61(5,-7.7) 62(5.4,-7.7) 63(5.8,-7.7) 64(6.2,-7.7) 97(6.2,7.7) 98(5.8,7.7) 99(5.4,7.7) 100(5,7.7) 101(4.6,7.7) 102(4.2,7.7) 103(3.8,7.7) 104(3.4,7.7) 105(3,7.7) 106(2.6,7.7) 107(2.2,7.7) 108(1.8,7.7) 109(1.4,7.7) 110(1,7.7) 111(0.6,7.7) 112(0.2,7.7) 113(-0.2,7.7) 114(-0.6,7.7) 115(-1,7.7) 116(-1.4,7.7) 117(-1.8,7.7) 118(-2.2,7.7) 119(-2.6,7.7) 120(-3,7.7) 121(-3.4,7.7) 122(-3.8,7.7) 123(-4.2,7.7) 124(-4.6,7.7) 125(-5,7.7) 126(-5.4,7.7) 127(-5.8,7.7) 128(-6.2,7.7)
TSSOP8_25-59_125X180_1-2
  rect 1.499x0.457 smd: 1(-2.9,0.975) 2(-2.9,0.325) 3(-2.9,-0.325) 4(-2.9,-0.975) 5(2.9,-0.975) 6(2.9,-0.325) 7(2.9,0.325) 8(2.9,0.975)
TSSOP14_25-59_205X180_1-2
  rect 1.499x0.457 smd: 1(-2.9,1.95) 2(-2.9,1.3) 3(-2.9,0.65) 4(-2.9,0) 5(-2.9,-0.65) 6(-2.9,-1.3) 7(-2.9,-1.95) 8(2.9,-1.95) 9(2.9,-1.3) 10(2.9,-0.65) 11(2.9,0) 12(2.9,0.65) 13(2.9,1.3) 14(2.9,1.95)
TSSOP16_25-59_205X180
  rect 1.6x0.356 smd: 1(-2.8,2.275) 2(-2.8,1.625) 3(-2.8,0.975) 4(-2.8,0.325) 5(-2.8,-0.325) 6(-2.8,-0.975) 7(-2.8,-1.625) 8(-2.8,-2.275) 9(2.8,-2.275) 10(2.8,-1.625) 11(2.8,-0.975) 12(2.8,-0.325) 13(2.8,0.325) 14(2.8,0.975) 15(2.8,1.625) 16(2.8,2.275)
TSSOP24_25-59_315X180_1-2
  rect 1.295x0.406 smd: 1(-2.8,3.575) 2(-2.8,2.925) 3(-2.8,2.275) 4(-2.8,1.625) 5(-2.8,0.975) 6(-2.8,0.325) 7(-2.8,-0.325) 8(-2.8,-0.975) 9(-2.8,-1.625) 10(-2.8,-2.275) 11(-2.8,-2.925) 12(-2.8,-3.575) 13(2.8,-3.575) 14(2.8,-2.925) 15(2.8,-2.275) 16(2.8,-1.625) 17(2.8,-0.975) 18(2.8,-0.325) 19(2.8,0.325) 20(2.8,0.975) 21(2.8,1.625) 22(2.8,2.275) 23(2.8,2.925) 24(2.8,3.575)
unnamed
  round 3.073 hole 3.2 unplated: (0,0)
unnamed#2
  round 0.686 hole 0.813 unplated: (-1.27,1.254) (-1.27,-1.254) (0,1.254) (0,-1.254) (1.27,1.254) (1.27,-1.254)
unnamed#3
  round 0.686 hole 0.813 unplated: (-1.27,1.254) (0,1.254) (1.27,1.254)
USON10_TPD4E05U_40X100_0-6
  rect 0.559x0.305 smd: 1(-0.385,1) 2(-0.385,0.5) 4(-0.385,-0.5) 5(-0.385,-1) 6(0.385,-1) 7(0.385,-0.5) 9(0.385,0.5) 10(0.385,1)
  rect 0.559x0.406 smd: 3(-0.385,0) 8(0.385,0)
VSON10_TPS74801-Q1_120X120_1
  rect 0.61x0.229 smd: 1(-1.4,1) 2(-1.4,0.5) 3(-1.4,0) 4(-1.4,-0.5) 5(-1.4,-1) 6(1.4,-1) 7(1.4,-0.5) 8(1.4,0) 9(1.4,0.5) 10(1.4,1)
  custom 0.412x0.412 smd: 11(0,0)
VSONHR8_TPS62823_60X80_1
  rect 0.559x0.254 smd: 1(-0.675,0.75) 2(-0.675,0.25) 3(-0.675,-0.25) 4(-0.675,-0.75) 5(0.675,-0.75) 6(0.675,-0.25) 7(0.675,0.25) 8(0.675,0.75)
VSSOP8_19-68_85X95_0-9
  rect 1.041x0.305 smd: 1(-1.65,0.75) 2(-1.65,0.25) 3(-1.65,-0.25) 4(-1.65,-0.75) 5(1.65,-0.75) 6(1.65,-0.25) 7(1.65,0.25) 8(1.65,0.75)
VSSOP8_25-59_120X120_1-1
  rect 1.397x0.457 smd: 1(-2.2,0.975) 2(-2.2,0.325) 3(-2.2,-0.325) 4(-2.2,-0.975) 5(2.2,-0.975) 6(2.2,-0.325) 7(2.2,0.325) 8(2.2,0.975)
WSON6_CSD13202Q2_80X80_0-8
  rect 0.457x0.305 smd: 1(-0.975,0.65) 2(-0.975,0) 3(-0.975,-0.65) 4(0.975,-0.65) 5(0.975,0) 6(0.975,0.65)
  rect 0.762x0.305 smd: 7(0.095,-0.65)
  rect 0.991x0.94 smd: 8(0,0.325)
WSON8_19-68_80X80_0-8
  rect 0.813x0.305 smd: 1(-1.1,0.75) 2(-1.1,0.25) 3(-1.1,-0.25) 4(-1.1,-0.75) 5(1.1,-0.75) 6(1.1,-0.25) 7(1.1,0.25) 8(1.1,0.75)
  rect 0.991x1.702 smd: 9(0,0)
X2QFN12_TUSB322I_60X60_0-4
  rect 0.711x0.203 smd: 1(-0.65,0.2) 2(-0.65,-0.2) 7(0.65,-0.2) 8(0.65,0.2)
  rect 0.203x0.508 smd: 3(-0.6,-0.75) 4(-0.2,-0.75) 5(0.2,-0.75) 6(0.6,-0.75) 9(0.6,0.75) 10(0.2,0.75) 11(-0.2,0.75) 12(-0.6,0.75)
X2SON8_15-74_70X50
  rect 0.838x0.203 smd: 1(-0.55,0.6) 2(-0.55,0.2) 3(-0.55,-0.2) 4(-0.55,-0.6) 5(0.55,-0.6) 6(0.55,-0.2) 7(0.55,0.2) 8(0.55,0.6)
XTAL4_LFXTAL055474_130X110_SMD_0-8
  rect 1.397x1.143 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)

## Nets
0V85_EN: R125.1 R127.2 U21.1(EN)
DGND: C1.2 C2.2 C3.1 C4.2 C5.2 C6.2 C7.2 C8.2 C9.1 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.1 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.1 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.1 C84.2 C85.2 C86.2 C87.2 C88.2 C89.1 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.1 C113.2 C114.2 C115.1 C116.2 C117.2 C118.2 C119.2 C120.1 C121.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.1 C128.2 C129.2 C130.2 C131.1 C132.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C139.2 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C161.2 C162.2 C163.2 C164.1 C165.2 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C192.2 C193.2 C194.2 C195.1 C196.2 C197.2 C198.2 C199.2 C200.2 C201.2 C202.2 C203.2 C204.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C219.2 C220.2 C221.2 C222.2 C223.2 C224.2 C225.2 C226.2 C227.2 C228.2 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.1 C262.2 C263.2 C264.1 C265.1 C266.2 C267.2 C268.2 C269.2 C270.2 D1.2(ANODE) D2.2(ANODE) D3.1(A) D4.2(ANODE) D5.2(ANODE) D6.2(ANODE) D7.2(ANODE) D8.2(ANODE) J1.4 J2.2 J5.4 J6.2 J9.2 J9.3 J10.A1(GND#A1) J10.A12(GND#A12) J10.B1(GND#B1) J10.B12(GND#B12) J10.G1(GND#G1) J10.G2(GND#G2) J11.2 J12.5 J13.1 J14.2 J14.3 J15.7 J15.16 J15.25 J15.34 J15.40 J15.41 J15.42 J16.3 J16.4 J17.1 J20.5(GND) J21.5 LD6.1(CATHODE) LD7.1(CATHODE) LD10.1(CATHODE) LD11.1(CATHODE) Q1.4(S1) Q1.7(S2) Q2.4(S1) Q2.7(S2) Q3.4(S1) Q3.7(S2) Q4.4(S1) Q4.7(S2) Q5.4(S1) Q5.7(S2) Q6.4(S1) Q6.7(S2) Q7.4(D1) Q7.7(D2) Q8.4(D1) Q8.7(D2) Q9.4(S1) Q9.7(S2) Q10.4(S1) Q10.7(S2) Q11.4(S1) Q11.7(S2) Q12.4(S1) Q12.7(S2) Q13.4(S1) Q13.7(S2) Q14.4(S1) Q14.7(S2) Q15.4(S1) Q15.7(S2) Q16.4(D1) Q16.7(D2) R9.1 R14.1 R16.2 R22.2 R24.1 R27.2 R33.2 R38.1 R47.2 R49.1 R52.2 R54.2 R64.2 R66.2 R69.2 R71.2 R72.2 R74.2 R75.2 R76.2 R77.2 R78.1 R83.1 R87.1 R90.1 R92.1 R102.2 R116.1 R119.1 R120.1 R121.1 R122.1 R123.2 R124.2 R125.2 R126.1 R128.1 R132.2 R133.2 R137.2 R138.2 R139.2 R142.2 R145.2 R147.2 R149.2 R151.2 R153.2 R155.2 R157.2 R159.2 R160.2 R165.1 R172.1 R173.1 R174.1 R175.1 R177.1 R184.2 R190.1 R195.2 R199.2 R200.2 R203.1 R204.1 R205.1 R206.1 R207.1 R208.1 R212.2 R221.2 R228.2 R232.2 R234.1 R239.2 R241.1 R242.2 R243.1 R245.1 R247.2 R250.1 R253.2 R255.2 R256.2 R260.2 R267.2 R276.1 R589.1 R591.1 R592.2 SW1.2 SW1.4 SW2.2 SW2.4 SW3.2 SW3.4 SW5.2 SW5.4 TP2.1(TP) TP9.1(TP) TP36.1(TP) TP37.1(TP) TP38.1(TP) U1.2(GND) U2.10(VSS) U3.2(GND) U4.10(A8) U4.11(GND1) U4.12(GND2) U4.13(GND3) U4.25(EP) U5.5(GND) U5.7(EP) U6.4(GND) U7.49(GND) U8.1(1\O\E\) U8.4(2\O\E\) U8.7(GND) U8.10(3\O\E\) U8.13(4\O\E\) U9.4(GND) U10.3(AGND) U10.5(PGND) U11.3(GND) U12.1(1\O\E\) U12.4(2\O\E\) U12.7(GND) U12.10(3\O\E\) U12.13(4\O\E\) U13.4(GND) U14.2(GND) U15.3(GND) U16.2(GND) U17.4(GND) U18.A1(VSS#A1) U18.A2(VSS#A2) U18.A20(VSS#A20) U18.A21(VSS#A21) U18.AA1(VSS#AA1) U18.AA2(VSS#AA2) U18.AA20(VSS#AA20) U18.AA21(VSS#AA21) U18.B1(VSS#B1) U18.B21(VSS#B21) U18.D10(VSS#D10) U18.D16(VSS#D16) U18.D17(VSS#D17) U18.E6(VSS#E6) U18.E11(VSS#E11) U18.E13(VSS#E13) U18.F8(VSS#F8) U18.F17(VSS#F17) U18.G16(VSS#G16) U18.H6(VSS#H6) U18.H7(VSS#H7) U18.H16(VSS#H16) U18.J5(VSS#J5) U18.J6(VSS#J6) U18.J11(VSS#J11) U18.J16(VSS#J16) U18.K6(VSS#K6) U18.K7(VSS#K7) U18.K8(VSS#K8) U18.K16(VSS#K16) U18.L10(VSS#L10) U18.L11(VSS#L11) U18.L12(VSS#L12) U18.M7(VSS#M7) U18.M15(VSS#M15) U18.M16(VSS#M16) U18.N6(VSS#N6) U18.N11(VSS#N11) U18.N13(VSS#N13) U18.P7(VSS#P7) U18.P11(VSS#P11) U18.P15(VSS#P15) U18.P16(VSS#P16) U18.R6(VSS#R6) U18.R11(VSS#R11) U18.T14(VSS#T14) U18.U6(VSS#U6) U18.Y1(VSS#Y1) U18.Y21(VSS#Y21) U19.49(GND) U20.10(GND) U20.11(EN_N) U21.3(AGND) U21.5(PGND) U22.5(GND) U22.9(E\N\) U23.5(GND) U23.9(EP) U24.3(GND#3) U24.8(GND#8) U25.2(1DIR) U25.3(2DIR) U25.8(GND1) U25.9(GND2) U25.14(2\O\E\) U25.15(1\O\E\) U26.6(GND) U26.17(EP) U27.12(GND) U27.21(EP) U28.3(GND) U29.3(GND) U30.5(GND) U30.9(E\N\) U31.3(GND) U32.2(DIR) U32.8(A6) U32.9(A7) U32.10(A8) U32.11(GND1) U32.12(GND2) U32.13(GND3) U32.14(B8) U32.15(B7) U32.16(B6) U33.6(GND) U33.11(EP) U34.3(GND) U35.8(G\) U35.16(GND) U36.1(ANODE) U37.10(GNDA) U37.17(GND#17) U37.48(GND#48) U37.55(GND#55) U37.58(GND#58) U37.64(W\A\K\E\) U37.66(XOSC0) U37.80(GND#80) U37.114(GND#114) U38.3(GND) U38.7(EP) U39.6(GND) U39.11(EP) U40.43(GND) U41.2(GND) U42.3(A2) U42.4(O\E\) U42.5(GND) U42.6(B2) U43.3(GND) U44.2(GND) U44.9(EP) U45.3(2DIR) U45.5(1A2) U45.7(2A2) U45.8(GND1) U45.9(GND2) U45.10(2B2) U45.12(1B2) U45.14(2\O\E\) U45.15(1\O\E\) U46.9(GND) U46.17(EP) Y1.2 Y1.4
VBAT_XDS: C208.1 R249.2 U37.68(VBAT)
VBUS_DETECT: R113.1 U20.4(VBUS_DET)
VBUS_TYPEC: C68.1 C70.1 D8.1(CATHODE) FL1.1 J10.A4(VBUS1) J10.A9(VBUS2) J10.B4(VBUS3) J10.B9(VBUS4) TP32.1(TP)
VBUS_XDS_USB: C170.1 J20.1(VBUS) R219.1 R222.2 TP27.1(TP) U24.1(IO1) U24.10(NC4) U38.4(EN) U38.6(IN)
VCC3V3_TA: C5.1 C31.1 C85.1 C88.1 C146.1 C155.1 C243.1 J15.1 J15.2 J15.3 R17.2 R28.2 R34.2 R48.2 R53.2 R67.2 R70.2 R178.1 R182.1 R186.1 R187.1 R189.2 R191.2 R196.2 R197.2 R202.2 R209.2 TP49.1(TP) U4.1(VCCA) U4.2(DIR) U9.5(EN) U9.8(VCCB) U26.14(VCCP) U26.15(VCCI) U28.5(VCC) U41.5(OUT)
VCC3V3_XDS: C44.1 C60.1 C104.1 C121.1 C151.1 C154.1 C180.1 C181.1 C182.1 C191.1 C240.1 C242.1 C260.1 C262.1 R98.2 R99.2 R100.2 R101.2 R108.2 R109.2 R235.1 R246.1 R249.1 TP35.1(TP) U16.7(VCCB) U25.16(VCCB) U37.7(VDD#7) U37.8(VDDA) U37.16(VDD#16) U37.26(VDD#26) U37.28(VDD#28) U37.39(VDD#39) U37.47(VDD#47) U37.51(VDD#51) U37.52(VDD#52) U37.69(VDD#69) U37.79(VDD#79) U37.90(VDD#90) U37.101(VDD#101) U37.113(VDD#113) U37.122(VDD#122) U38.1(OUT) U42.8(VCCB) U45.16(VCCB)
VCC_5V0_CAN: C257.1 R270.2 TP50.1(TP) U44.3(VCC)
VDD_1V1: C17.1 C19.1 C34.1 C55.1 C56.1 C61.1 C95.1 C96.1 C97.1 C98.1 C113.1 C216.1 C217.1 C221.1 C222.1 C228.1 C229.1 C256.1 R248.1 TP30.1(TP) U7.6(VDDA1P1) U7.31(VDD1P1#31) U7.39(VDD1P1#39) U19.6(VDDA1P1) U19.31(VDD1P1#31) U19.39(VDD1P1#39) U39.9(OUT1) U39.10(OUT2)
VDD_1V1_SS: C183.1 U39.7(SS)
VDD_1V8: C30.2 C162.1 FB1.1 FB2.1 FB5.1 FB6.1 FB7.1 FB8.1 FB9.1 R29.2 R30.2 R198.1 TP5.1(TP) U11.5(VCC) U18.F14(VMON_1P8_SOC)
VDD_1V8_CT: C80.1 U27.5(CT1)
VDD_1V8_ENABLE: R31.1 R224.1 U10.8(PG)
VDD_1V8_R: C18.1 C20.1 R30.1 U5.1(OUT)
VDD_1V8_SENSE: R198.2 R199.1 U27.10(SENSE1)
VDD_2V5: C11.1 C23.1 C53.1 C58.1 C92.1 C99.1 C100.1 C107.1 C125.1 C130.1 C197.1 C230.1 C231.1 C238.1 R81.2 R233.1 TP20.1(TP) U7.3(VDDA2P5#3) U7.9(VDDA2P5#9) U19.3(VDDA2P5#3) U19.9(VDDA2P5#9) U33.9(OUT1) U33.10(OUT2)
VDD_2V5_PG: R81.1 U33.3(PG) U39.5(EN)
VDD_2V5_SS: C111.1 U33.7(SS)
VDD_CORE_0V85: C48.1 C49.1 C52.1 C62.1 C136.1 C137.1 C138.1 C139.1 C163.1 C165.1 C186.1 C187.1 C188.1 C199.1 C200.1 C201.1 C211.1 C212.1 C214.1 C227.1 C234.1 C239.1 C244.1 C247.1 C250.1 C251.1 C254.1 C255.1 R96.1 R130.1 R176.2 TP23.1(TP) U18.F11(VDD_CORE#F11) U18.G5(VDDR_CORE#G5) U18.G6(VDDR_CORE#G6) U18.G10(VDD_CORE#G10) U18.H8(VDD_CORE#H8) U18.H15(VDD_CORE#H15) U18.J9(VDD_CORE#J9) U18.J10(VDDR_CORE#J10) U18.J12(VDDR_CORE#J12) U18.K11(VDD_CORE#K11) U18.K14(VDD_CORE#K14) U18.L9(VDD_CORE#L9) U18.L13(VDD_CORE#L13) U18.M8(VDD_CORE#M8) U18.M14(VDD_CORE#M14) U18.N9(VDD_CORE#N9) U18.N10(VDD_CORE#N10) U18.P8(VDDR_CORE#P8) U18.P14(VDDR_CORE#P14) U18.R9(VDD_CORE#R9) U18.R10(VDDR_CORE#R10) U18.R12(VDD_CORE#R12) U18.R13(VDD_CORE#R13) U18.V16(VDDA_0P85_USB0)
VDD_CORE_0V85_EN: R29.1 R127.1 U5.3(PG)
VDD_CORE_0V85_FB: C62.2 R124.1 R130.2 U21.2(FB)
VDD_CORE_0V85_H_SENSE: R6.1 R175.2 U27.6(SENSE4H)
VDD_CORE_0V85_L_SENSE: R6.2 R176.1 U27.7(SENSE4L)
VDD_CORE_0V85_PG: Q3.3(G) R112.1 U21.8(PG)
VDD_CORE_0V85_R: C50.1 L2.2 R96.2
VDD_CORE_0V85_SW: L2.1 U21.6(SW)
VDDA_1P8_USB0: C176.1 C177.1 C179.1 FB5.2 TP47.1(TP) U18.U15(VDDA_1P8_USB0)
VDDA_1V8: C4.1 C126.1 C135.1 C144.1 C153.1 FB2.2 R15.2 TP40.1(TP) U1.5(VCC) U18.F18(VDDS_OSC) U18.H14(VDDA_MCU)
VDDA_3P3_USB0: C156.1 C157.1 C178.1 FB4.2 TP45.1(TP) U18.U16(VDDA_3P3_USB0)
VDDA_3V3: C142.1 C174.1 FB3.2 TP43.1(TP) U18.K15(VDDA_3P3_SDIO)
VDDA_ADC: C109.1 C116.1 C147.1 C148.1 FB1.2 TP48.1(TP) U18.G17(VDDA_ADC#G17) U18.H17(VDDA_ADC#H17)
VDDA_PLL0: C185.1 C204.1 C206.1 FB7.2 TP41.1(TP) U18.N12(VDDA_PLL0)
VDDA_PLL1: C210.1 C236.1 C241.1 FB9.2 TP44.1(TP) U18.G9(VDDA_PLL1)
VDDA_PLL2: C184.1 C193.1 C194.1 FB6.2 TP46.1(TP) U18.G12(VDDA_PLL2)
VDDA_TEMP: C190.1 C198.1 C224.1 C225.1 FB8.2 TP42.1(TP) U18.G11(VDDA_TEMP0) U18.M11(VDDA_TEMP1)
VDDC_1V2_XDS: C102.1 C105.1 C132.1 U37.87(VDDC#87) U37.115(VDDC#115)
VDDSHV_3V3: C133.1 C134.1 C140.1 C141.1 C145.1 C158.1 C167.1 C168.1 C169.1 C171.1 C175.1 C189.1 C202.1 C203.1 C205.1 C213.1 C215.1 C235.1 C237.1 C245.1 C246.1 C249.1 C253.1 R261.2 TP52.1(TP) U18.C13(VDDSHV0#C13) U18.D13(VDDSHV0#D13) U18.E7(VDDSHV_MCU#E7) U18.E8(VDDSHV_MCU#E8) U18.E9(VDDSHV_MCU#E9) U18.E14(VDDSHV0#E14) U18.E15(VMON_3P3_SOC) U18.L6(VDDSHV1#L6) U18.M6(VDDSHV1#M6) U18.N16(VDDSHV4#N16) U18.N17(VDDSHV4#N17) U18.P5(VDDSHV1#P5) U18.P6(VDDSHV1#P6) U18.R17(VDDSHV3#R17) U18.T8(VDDSHV2#T8) U18.T11(VDDSHV2#T11) U18.T17(VDDSHV3#T17) U18.U7(VDDSHV2#U7) U18.U8(VDDSHV2#U8) U18.U11(VDDSHV2#U11)
VDDSHV_SDIO: C143.1 C160.1 C172.1 R19.2 R21.2 R192.2 R193.2 R194.2 U18.J17(CAP_VDDSHV_MMC1) U18.L16(VDDSHV5#L16) U18.L17(VDDSHV5#L17)
BOARD_POWER_EN: R84.2 R85.1 U10.1(EN)
BOOTMODE0: R39.1 R55.2 R208.2
BOOTMODE0_R: R55.1 U18.R21(GPMC0_AD0) U32.3(A1)
BOOTMODE1: R40.1 R56.2 R207.2
BOOTMODE2: R41.1 R206.2 R215.2
BOOTMODE2_R: R215.1 U18.T19(GPMC0_AD2) U32.7(A5)
BOOTMODE3: R42.2 U4.21(B1)
BOOTMODE4: R59.2 U4.20(B2)
BOOTMODE5: R57.2 U4.19(B3)
BOOTMODE6: R217.2 U4.18(B4)
BOOTMODE7: R216.2 U4.17(B5)
BOOTMODE8: R214.2 U4.16(B6)
BOOTMODE8_R: R214.1 U18.U18(GPMC0_AD8) U32.4(A2)
BOOTMODE9: R58.2 U4.15(B7)
BOOTMODE9_R: R58.1 U18.U20(GPMC0_AD9) U32.5(A3)
BOOTMODE10: R43.1 R60.2 R205.2
BOOTMODE10_R: R60.1 U18.V20(GPMC0_AD10) U32.6(A4)
BOOTMODE11: R44.1 R61.2 R204.2
BOOTMODE12: R45.1 R62.2 R203.2
BOOTMODE14: R586.2 R588.1 R589.2
BOOTMODE15: R587.2 R590.1 R591.2
BOOTMODEON: R24.2 U4.22(O\E\) U28.4(Y)
BP_3V3: J5.1 R163.2
BP_5V0: J5.2 R161.1
BP_ADC0_AIN0: J1.3 R143.1
BP_ADC0_AIN1: J1.11 R152.1
BP_ADC0_AIN2: J1.6 R144.1
BP_ADC0_AIN3: J1.8 R146.1
BP_ADC0_AIN4: J1.10 R148.1
BP_ADC0_AIN5: J1.12 R150.1
BP_ADC0_AIN6: J1.14 R154.1
BP_ADC0_AIN7: J1.16 R156.1
BP_CONN_1_PORZ: J2.10 R8.1
BP_CONN_2_PORZ: J6.10 R2.1
BUFF_ENABLE: U29.4(Y) U32.22(O\E\)
CAP_VDDS0: C192.1 U18.D12(CAP_VDDS0)
CAP_VDDS1: C233.1 U18.N5(CAP_VDDS1)
CAP_VDDS2: C196.1 U18.U9(CAP_VDDS2)
CAP_VDDS3: C173.1 U18.R16(CAP_VDDS3)
CAP_VDDS4: C149.1 U18.N18(CAP_VDDS4)
CAP_VDDS5: C150.1 U18.M18(CAP_VDDS5)
CAP_VDDS_MCU: C223.1 U18.D9(CAP_VDDS_MCU)
CORE_0V85_CT: C82.1 U27.2(CT4)
CPSW_RGMII1_RD0: U18.T5(PRG0_PRU1_GPO7) U40.28(C6)
CPSW_RGMII1_RD1: U18.R2(PRG0_PRU1_GPO9) U40.26(C7)
CPSW_RGMII1_RD2: U18.U2(PRG0_PRU1_GPO10) U40.24(C8)
CPSW_RGMII1_RD3: U18.T1(PRG0_PRU1_GPO17) U40.22(C9)
CPSW_RGMII1_RX_CTL: U18.Y3(PRG0_PRU0_GPO9) U40.20(C10)
CPSW_RGMII1_RXC: U18.U1(PRG0_PRU0_GPO10) U40.18(C11)
CPSW_RGMII1_TD0: U18.Y14(PRG1_PRU1_GPO7) U40.42(C0)
CPSW_RGMII1_TD1: U18.Y16(PRG1_PRU1_GPO9) U40.40(C1)
CPSW_RGMII1_TD2: U18.U13(PRG1_PRU1_GPO10) U40.37(C2)
CPSW_RGMII1_TD3: U18.AA14(PRG1_PRU1_GPO17) U40.35(C3)
CPSW_RGMII1_TX_CTL: U18.W16(PRG1_PRU0_GPO9) U40.33(C4)
CPSW_RGMII1_TXC: R287.2 U40.31(C5)
DEBOUNCE_MCU_RESETZ: C1.1 D1.1(CATHODE) R1.1 SW2.1 SW2.3 U13.1(1A)
DEBOUNCE_SOC_RESET_REQZ: C2.1 D2.1(CATHODE) Q7.1(S1) Q7.2(S2) Q7.5(S3) Q7.6(S4) Q7.8(S5) R170.1 SW3.1 SW3.3 U13.6(3A)
DEBOUNCE_USER_INTN: C78.1 D4.1(CATHODE) Q16.1(S1) Q16.2(S2) Q16.5(S3) Q16.6(S4) Q16.8(S5) R164.1 SW5.1 SW5.3 U13.3(2A)
EEPROM_A1: R121.2 U17.2(A1)
EEPROM_A2: R122.2 U17.3(A2)
EEPROM_WP: R89.1 U17.7(WP)
EHRPWM0_A: J2.1 R42.1 U18.V21(GPMC0_AD3)
EHRPWM0_B: J2.3 R59.1 U18.U21(GPMC0_AD4)
EHRPWM0_TZN_IN0: J2.13 U32.17(B5)
EHRPWM1_A: J2.5 R57.1 U18.T20(GPMC0_AD5)
EHRPWM1_B: J2.7 R217.1 U18.T18(GPMC0_AD6)
EHRPWM2_A: J2.9 U30.3(A1)
EHRPWM2_B: J2.11 U30.7(B1)
EPHY1_XI: R13.2 R185.2 U7.20(XI)
EQEP1_A: C77.1 J12.1 R279.2 U46.16(B1)
EQEP1_A_LS: U18.L2(PRG0_PRU1_GPO3) U46.1(A1)
EQEP1_B: C76.1 J12.2 R280.2 U46.14(B2)
EQEP1_B_LS: U18.L3(PRG0_PRU1_GPO4) U46.3(A2)
EQEP1_I: C75.1 J12.3 R281.2 U46.13(B3)
EQEP1_I_LS: U18.R5(PRG0_PRU1_GPO14) U46.4(A3)
EQEP2_A: C73.1 J21.1 R272.2 U46.12(B4)
EQEP2_A_LS: U18.B14(MCAN1_TX) U46.5(A4)
EQEP2_B: C72.1 J21.2 R273.2 U46.11(B5)
EQEP2_B_LS: R244.2 U46.6(A5)
EQEP2_I: C71.1 J21.3 R274.2 U46.10(B6)
EQEP2_I_LS: U22.3(A1) U46.7(A6)
ETH1_EARTH: C252.1 J19.SH1 J19.SH2 R253.1
ETH2_EARTH: C101.1 J18.SH1 J18.SH2 R200.1
FB_1V1: R247.1 R248.2 U39.8(FB)
FB_2V5: R232.1 R233.2 U33.8(FB)
FSI/BP_MUX_SEL: R190.2 U18.Y19(GPMC0_AD13) U30.1(SEL)
FSI_RX0_CLK: J16.1 U30.2(A0)
FSI_RX0_D0: J16.5 U30.8(B0)
FSI_RX0_D1: J16.7 U32.18(B4)
FSI_RX0CLK_PWM2A: U30.4(A) U32.20(B2)
FSI_RX0D0_PWM2B: U30.6(B) U32.19(B3)
FSI_TX0_CLK: J16.2 U18.P21(GPMC0_BE1N)
FSI_TX0_D0: J16.6 R586.1 U18.Y18(GPMC0_AD14)
FSI_TX0_D1: J16.8 R587.1 U18.AA19(GPMC0_AD15)
GPIO0_50: J5.11 U18.U14(PRG1_PRU0_GPO5)
GPIO1_0: J2.15 U18.J3(PRG0_PRU0_GPO0)
GPIO1_1: J2.17 U18.J4(PRG0_PRU0_GPO1)
GPIO1_2: J2.19 U18.G1(PRG0_PRU0_GPO2)
GPIO1_3: J2.4 U18.H1(PRG0_PRU0_GPO3)
GPIO1_4: J2.8 U18.K2(PRG0_PRU0_GPO4)
GPIO1_5: J2.16 U18.F2(PRG0_PRU0_GPO5)
GPIO1_6: J5.15 U18.H2(PRG0_PRU0_GPO6)
GPIO1_8: J6.20 U18.H5(PRG0_PRU0_GPO8)
GPIO1_12: J1.9 U18.K1(PRG0_PRU0_GPO12)
GPIO1_18: J1.15 U18.K4(PRG0_PRU0_GPO18)
GPIO1_19: J5.9 U18.G2(PRG0_PRU0_GPO19)
GPIO1_20: J2.20 U18.L5(PRG0_PRU1_GPO0)
GPIO1_21: J5.14 U18.J2(PRG0_PRU1_GPO1)
GPIO1_22: J5.16 U18.M2(PRG0_PRU1_GPO2)
GPIO1_26: J5.18 U18.F5(PRG0_PRU1_GPO6)
GPIO1_31: J5.20 U18.P1(PRG0_PRU1_GPO11)
GPIO1_32: J6.17 U18.P2(PRG0_PRU1_GPO12)
GPIO1_33: J6.19 U18.T4(PRG0_PRU1_GPO13)
GPIO1_35: J6.4 U18.M4(PRG0_PRU1_GPO15)
GPIO1_36: J6.8 U18.T3(PRG0_PRU1_GPO16)
GPIO1_40: J6.16 U18.E4(PRG0_MDIO0_MDIO)
GPIO1_41: J6.18 U18.D2(PRG0_MDIO0_MDC)
GPIO1_61: TP34.1(TP) U22.7(B1)
GPIO1_77: J6.13 U18.B17(MMC1_SDCD)
GPIO1_78: J6.15 U18.C16(MMC1_SDWP)
GPIO_OSPI0_RESET_N: R181.1 U18.M20(OSPI0_CSN1) U31.1(A)
GPIO_RGMII1_PHY_RSTN: R275.1 U18.W11(PRG1_PRU1_GPO8) U43.1(A)
GPIO_RGMII2_PHY_RSTN: R236.1 U18.Y15(PRG1_PRU1_GPO18) U34.1(A)
LED1: LD15.1(CATHODE) U35.3(DRAIN0)
LED2: LD14.1(CATHODE) U35.4(DRAIN1)
LED3: LD13.1(CATHODE) U35.5(DRAIN2)
LED4: LD12.1(CATHODE) U35.6(DRAIN3)
LED_DRV_A0: R245.2 U35.9(A0)
LED_DRV_A1: R241.2 U35.10(A1)
LED_DRV_A2: R243.2 U35.7(A2)
LMK_1G: R32.1 U6.2(1G)
LMK_CLK_IN: R26.2 U6.1(CLKIN)
LMK_CLK_IN_R: R26.1 U3.3(OUTPUT)
MAIN_UART0_RXD: U18.B10(UART0_RXD) U45.6(2A1)
MAIN_UART0_TXD: R592.1 U18.B11(UART0_TXD) U45.4(1A1)
MAIN_UART1_CTS#: U12.11(4B) U18.C11(UART1_CTSN)
MAIN_UART1_RTS#: U12.5(2A) U18.A11(UART1_RTSN)
MAIN_UART1_RXD: U12.8(3B) U18.B12(UART1_RXD)
MAIN_UART1_TXD: U12.2(1A) U18.A12(UART1_TXD)
MAIN_UART2_RXD: J1.5 U32.21(B1)
MAIN_UART2_TXD: J1.7 R56.1 U18.R20(GPMC0_AD1)
MAIN_UART4_RXD: J5.5 U18.L1(PRG0_PRU0_GPO11)
MAIN_UART4_TXD: J5.7 U18.E2(PRG0_PRU0_GPO7)
MCAN0_H: J11.1 R278.1 U44.7(CANH)
MCAN0_L: J11.3 R277.2 U44.6(CANL)
MCAN0_RX: R263.2 U44.4(RXD)
MCAN0_RX_MUX: U18.A14(MCAN0_RX) U22.6(B)
MCAN0_RX_SYNC3_OUT: R131.1 R263.1 U22.8(B0)
MCAN0_STB: R276.2 U18.E3(PRG0_PRU1_GPO5) U44.8(STB)
MCAN0_T: C267.1 R277.1 R278.2
MCAN0_TX: R259.2 U44.1(TXD)
MCAN0_TX_EQEP2_I: U18.B13(MCAN0_TX) U22.4(A)
MCAN0_TX_SYNC2_OUT: R140.1 R259.1 U22.2(A0)
MCAN/EQEP_MUX_SEL: R128.2 U18.F4(PRG0_PRU1_GPO8) U22.1(SEL)
MCU_PORZ: TP1.1(TP) U1.4(Y) U18.C20(MCU_PORZ)
MCU_RESETSTATZ: R126.2 R180.1 TP31.1(TP) U18.A6(MCU_RESETSTATZ)
MCU_RESETZ: TP19.1(TP) U13.7(1Y) U18.A5(MCU_RESETZ)
MCU_SAFTY_ERRZ: TP22.1(TP) U18.B20(MCU_SAFETY_ERRORN)
MCU_UART0_CTS#: U8.11(4B) U18.D4(MCU_UART0_CTSN)
MCU_UART0_RTS#: U8.5(2A) U18.C2(MCU_UART0_RTSN)
MCU_UART0_RXD: U8.8(3B) U18.D6(MCU_UART0_RXD)
MCU_UART0_TXD: U8.2(1A) U18.B2(MCU_UART0_TXD)
OBSCLK0: R185.1 R240.2
OSC0: C131.2 U37.88(OSC0) Y1.3
OSC0_XO: R78.2 U18.C21(MCU_OSC0_XO)
OSC1: C120.2 U37.89(OSC1) Y1.1
OSC_STB#: R49.2 U3.1(ENABLE/DISABLE)
OSPI0_CLK: R54.1 R63.2 U2.16(CK)
OSPI0_CLK_R: R63.1 U18.P20(OSPI0_CLK)
OSPI0_CS0_N: R183.1 U2.7(CS#) U18.L20(OSPI0_CSN0)
OSPI0_D0: R36.1 U2.15(DQ0/SI) U18.L19(OSPI0_D0)
OSPI0_D1: R10.1 U2.8(DQ1/SO) U18.N20(OSPI0_D1)
OSPI0_D2: R5.1 U2.9(DQ2/WP#) U18.L21(OSPI0_D2)
OSPI0_D3: R37.1 U2.1(DQ3/RESET#) U18.N19(OSPI0_D3)
OSPI0_DQS: R213.1 U18.P17(OSPI0_DQS)
OSPI0_DQS_R: R65.1 R213.2
OSPI0_LBCLKO: R65.2 U18.M21(OSPI0_LBCLKO)
PORZ_OUT: R87.2 R179.1 TP14.1(TP) U18.D18(PORZ_OUT) U28.2(B) U29.2(A) U34.2(B) U43.2(B)
PRG1_CPSW_ETH1_CLK_OUT: TP33.1(TP) U19.40(CLK_OUT)
PRG1_CPSW_ETH1_D0M: J19.10 U19.2(TD_M_A)
PRG1_CPSW_ETH1_D0P: J19.11 U19.1(TD_P_A)
PRG1_CPSW_ETH1_D1M: J19.5 U19.5(TD_M_B)
PRG1_CPSW_ETH1_D1P: J19.4 U19.4(TD_P_B)
PRG1_CPSW_ETH1_D2M: J19.2 U19.8(TD_M_C)
PRG1_CPSW_ETH1_D2P: J19.3 U19.7(TD_P_C)
PRG1_CPSW_ETH1_D3M: J19.9 U19.11(TD_M_D)
PRG1_CPSW_ETH1_D3P: J19.8 U19.10(TD_P_D)
PRG1_CPSW_ETH1_LED1: J19.13 Q13.1(D1) Q13.2(D2) Q13.5(D3) Q13.6(D4) Q13.8(D5)
PRG1_CPSW_ETH1_LED2: J19.16 Q14.1(D1) Q14.2(D2) Q14.5(D3) Q14.6(D4) Q14.8(D5) R252.1
PRG1_CPSW_ETH1_LED3: J19.15 Q15.1(D1) Q15.2(D2) Q15.5(D3) Q15.6(D4) Q15.8(D5) R257.1
PRG1_CPSW_ETH1_LED_1000/RX_ER: Q14.3(G) R138.1 R265.2 U19.46(LED_1/RX_ER)
PRG1_CPSW_ETH1_LED_ACT: Q15.3(G) R137.1 R266.2 U19.45(LED_2/GPIO_0)
PRG1_CPSW_ETH1_LED_LINK: Q13.3(G) R139.1 R264.2 U19.47(LED_0)
PRG1_CPSW_ETH1_RBIAS: R102.1 U19.12(RBIAS)
PRG1_CPSW_ETH2_CLK_OUT: TP11.1(TP) U7.40(CLK_OUT)
PRG1_CPSW_ETH2_D0M: J18.10 U7.2(TD_M_A)
PRG1_CPSW_ETH2_D0P: J18.11 U7.1(TD_P_A)
PRG1_CPSW_ETH2_D1M: J18.5 U7.5(TD_M_B)
PRG1_CPSW_ETH2_D1P: J18.4 U7.4(TD_P_B)
PRG1_CPSW_ETH2_D2M: J18.2 U7.8(TD_M_C)
PRG1_CPSW_ETH2_D2P: J18.3 U7.7(TD_P_C)
PRG1_CPSW_ETH2_D3M: J18.9 U7.11(TD_M_D)
PRG1_CPSW_ETH2_D3P: J18.8 U7.10(TD_P_D)
PRG1_CPSW_ETH2_LED1: J18.13 Q10.1(D1) Q10.2(D2) Q10.5(D3) Q10.6(D4) Q10.8(D5)
PRG1_CPSW_ETH2_LED2: J18.16 Q11.1(D1) Q11.2(D2) Q11.5(D3) Q11.6(D4) Q11.8(D5) R220.1
PRG1_CPSW_ETH2_LED3: J18.15 Q12.1(D1) Q12.2(D2) Q12.5(D3) Q12.6(D4) Q12.8(D5) R223.1
PRG1_CPSW_ETH2_LED_1000/RX_ER: Q11.3(G) R75.1 R226.2 U7.46(LED_1/RX_ER)
PRG1_CPSW_ETH2_LED_ACT: Q12.3(G) R74.1 R227.2 U7.45(LED_2/GPIO_0)
PRG1_CPSW_ETH2_LED_LINK: Q10.3(G) R76.1 R225.2 U7.47(LED_0)
PRG1_CPSW_ETH2_RBIAS: R22.1 U7.12(RBIAS)
PRG1_CPSW_RGMII1_CLK: R25.2 U19.20(XI)
PRG1_CPSW_RGMII1_CLK_R: R25.1 U6.8(Y1)
PRG1_CPSW_RGMII1_GPIO_1: R95.2 R242.1 U19.22(JTAG_TDO/GPIO_1)
PRG1_CPSW_RGMII1_RD0: R123.1 R254.2 U19.33(RX_D0) U40.11(A6)
PRG1_CPSW_RGMII1_RD1: R129.2 R260.1 U19.34(RX_D1) U40.12(A7)
PRG1_CPSW_RGMII1_RD2: R132.1 R269.2 U19.35(RX_D2) U40.13(A8)
PRG1_CPSW_RGMII1_RD3: R133.1 R268.2 U19.36(RX_D3) U40.14(A9)
PRG1_CPSW_RGMII1_RSTN: U19.43(RESET_N) U43.4(Y)
PRG1_CPSW_RGMII1_RX_CTL: R134.2 R267.1 U19.38(RX_CTRL/RX_DV) U40.15(A10)
PRG1_CPSW_RGMII1_RXC: R115.1 U40.16(A11)
PRG1_CPSW_RGMII1_RXC_R: R115.2 U19.32(RX_CLK)
PRG1_CPSW_RGMII1_TD0: U19.28(TX_D0) U40.2(A0)
PRG1_CPSW_RGMII1_TD1: U19.27(TX_D1) U40.3(A1)
PRG1_CPSW_RGMII1_TD2: U19.26(TX_D2) U40.4(A2)
PRG1_CPSW_RGMII1_TD3: U19.25(TX_D3) U40.5(A3)
PRG1_CPSW_RGMII1_TX_CTL: U19.37(TX_CTRL/TX_EN) U40.6(A4)
PRG1_CPSW_RGMII1_TXC: U19.29(GTX_CLK/TX_CLK) U40.7(A5)
PRG1_CPSW_RGMII2_CLK: R13.1 R50.2
PRG1_CPSW_RGMII2_CLK_R: R50.1 U6.5(Y2)
PRG1_CPSW_RGMII2_GPIO_1: R12.2 R184.1 U7.22(JTAG_TDO/GPIO_1)
PRG1_CPSW_RGMII2_RD0: R64.1 R218.2 U7.33(RX_D0) U18.AA10(PRG1_PRU1_GPO0)
PRG1_CPSW_RGMII2_RD1: R68.2 R221.1 U7.34(RX_D1) U18.Y10(PRG1_PRU1_GPO1)
PRG1_CPSW_RGMII2_RD2: R71.1 R230.2 U7.35(RX_D2) U18.Y11(PRG1_PRU1_GPO2)
PRG1_CPSW_RGMII2_RD3: R72.1 R229.2 U7.36(RX_D3) U18.V12(PRG1_PRU1_GPO3)
PRG1_CPSW_RGMII2_RSTN: U7.43(RESET_N) U34.4(Y)
PRG1_CPSW_RGMII2_RX_CTL: R73.2 R228.1 U7.38(RX_CTRL/RX_DV) U18.Y12(PRG1_PRU1_GPO4)
PRG1_CPSW_RGMII2_RXC: R51.1 U18.V10(PRG1_PRU1_GPO6)
PRG1_CPSW_RGMII2_RXC_R: R51.2 U7.32(RX_CLK)
PRG1_CPSW_RGMII2_TD0: U7.28(TX_D0) U18.Y6(PRG1_PRU1_GPO11)
PRG1_CPSW_RGMII2_TD1: U7.27(TX_D1) U18.AA8(PRG1_PRU1_GPO12)
PRG1_CPSW_RGMII2_TD2: U7.26(TX_D2) U18.Y9(PRG1_PRU1_GPO13)
PRG1_CPSW_RGMII2_TD3: U7.25(TX_D3) U18.W9(PRG1_PRU1_GPO14)
PRG1_CPSW_RGMII2_TX_CTL: U7.37(TX_CTRL/TX_EN) U18.V9(PRG1_PRU1_GPO15)
PRG1_CPSW_RGMII2_TXC: R23.1 U18.Y8(PRG1_PRU1_GPO16)
PRG1_CPSW_RGMII2_TXC_R: R23.2 U7.29(GTX_CLK/TX_CLK)
PRG1_CPSW_RGMII_INTN: R136.2 U7.44(INT_N/PWDN_N) U18.AA13(PRG1_PRU1_GPO19) U19.44(INT_N/PWDN_N)
PRG1_IEP0_EDC_LATCH_IN0: J5.8 U18.Y4(PRG1_PRU0_GPO18)
PRG1_IEP0_EDC_LATCH_IN1: J5.12 U18.V13(PRG1_PRU0_GPO7)
PRG1_IEP0_EDC_SYNC_OUT0: J5.6 U18.U3(PRG1_PRU0_GPO19)
PRG1_IEP0_EDC_SYNC_OUT1: J5.10 U18.T2(PRG1_PRU0_GPO17)
PRG1_MDIO0_MDC: U7.42(MDC) U18.W1(PRG1_MDIO0_MDC) U19.42(MDC)
PRG1_MDIO0_MDIO: R135.2 U7.41(MDIO) U18.V2(PRG1_MDIO0_MDIO) U19.41(MDIO)
PRG1_RGMII1_RD0: U18.V4(PRG1_PRU0_GPO0) U40.29(B6)
PRG1_RGMII1_RD1: U18.W5(PRG1_PRU0_GPO1) U40.27(B7)
PRG1_RGMII1_RD2: U18.AA4(PRG1_PRU0_GPO2) U40.25(B8)
PRG1_RGMII1_RD3: U18.Y5(PRG1_PRU0_GPO3) U40.23(B9)
PRG1_RGMII1_RX_CTL: U18.AA5(PRG1_PRU0_GPO4) U40.21(B10)
PRG1_RGMII1_RXC: U18.Y2(PRG1_PRU0_GPO6) U40.19(B11)
PRG1_RGMII1_TD0: U18.V5(PRG1_PRU0_GPO11) U40.41(B0)
PRG1_RGMII1_TD1: U18.W2(PRG1_PRU0_GPO12) U40.39(B1)
PRG1_RGMII1_TD2: U18.V6(PRG1_PRU0_GPO13) U40.38(B2)
PRG1_RGMII1_TD3: U18.AA7(PRG1_PRU0_GPO14) U40.36(B3)
PRG1_RGMII1_TX_CTL: U18.Y7(PRG1_PRU0_GPO15) U40.34(B4)
PRG1_RGMII1_TXC: R286.2 U40.32(B5)
PRG_CPSW_RGMII1_MUX_SEL: R250.2 U18.AA11(PRG1_PRU1_GPO5) U40.9(SEL1) U40.10(SEL2)
QSPI_RST_N: U2.3(RESET#) U31.4(Y)
R_BP_CONN_1_PORZ: R4.1 R8.2 U1.3(B)
R_BP_CONN_2_PORZ: R2.2 R3.1 U1.6(C)
SENCE3_IP: R188.2 U27.8(SENSE3)
SOC_ADC0_AIN0: C28.1 R142.1 R143.2 U18.H21(ADC0_AIN0)
SOC_ADC0_AIN1: C118.1 R152.2 R153.1 U18.F19(ADC0_AIN1)
SOC_ADC0_AIN2: C110.1 R144.2 R145.1 U18.F21(ADC0_AIN2)
SOC_ADC0_AIN3: C108.1 R146.2 R147.1 U18.F20(ADC0_AIN3)
SOC_ADC0_AIN4: C33.1 R148.2 R149.1 U18.H20(ADC0_AIN4)
SOC_ADC0_AIN5: C117.1 R150.2 R151.1 U18.E21(ADC0_AIN5)
SOC_ADC0_AIN6: C35.1 R154.2 R155.1 U18.G20(ADC0_AIN6)
SOC_ADC0_AIN7: C36.1 R156.2 R157.1 U18.E20(ADC0_AIN7)
SOC_CLKIN: U11.4(Y) U18.D20(MCU_OSC0_XI)
SOC_CLKIN_BUFF: R46.2 U11.2(A)
SOC_CLKIN_BUFF_R: R46.1 U6.3(Y0)
SOC_CPSW_RGMII1_TXC: R287.1 U18.W13(PRG1_PRU0_GPO10)
SOC_EMU0: U16.5(A1) U18.C5(EMU0)
SOC_EMU1: U16.4(A2) U18.B3(EMU1)
SOC_I2C0_SCL: R93.1 R141.1 R237.2 U17.6(SCL) U35.15(SCL)
SOC_I2C0_SCL_BP: J5.17 R141.2
SOC_I2C0_SCL_RC: C47.1 R93.2 U18.B16(I2C0_SCL)
SOC_I2C0_SDA: R97.1 R158.1 R238.2 U17.5(SDA) U35.2(SDA)
SOC_I2C0_SDA_BP: J5.19 R158.2
SOC_I2C0_SDA_RC: C161.1 R97.2 U18.B15(I2C0_SDA)
SOC_I2C1_SCL: J1.17 R88.2 U9.2(SCLA) U18.A17(I2C1_SCL)
SOC_I2C1_SDA: J1.19 R82.2 U9.3(SDAA) U18.B18(I2C1_SDA)
SOC_I2C1_TA_SCL: J15.36 R187.2 U9.7(SCLB)
SOC_I2C1_TA_SDA: J15.38 R182.2 U9.6(SDAB)
SOC_PRG1_RGMII1_TXC: R286.1 U18.W6(PRG1_PRU0_GPO16)
SOC_RESET_REQZ: TP24.1(TP) U13.2(3Y) U18.C17(RESET_REQZ)
SOC_RESETSTATZ: R234.2 TP13.1(TP) U18.E19(RESETSTATZ)
SOC_TCK: R162.1 U18.C6(TCK)
SOC_TDI: U18.A3(TDI) U25.5(1A2)
SOC_TDO: R271.1 U42.2(A1)
SOC_TMS: U18.B4(TMS) U25.6(2A1)
SOC_TRST#: R120.2 U18.B6(TRSTN) U25.7(2A2)
SPI0_CLK: J5.13 U18.B8(SPI0_CLK)
SPI0_CS1: J6.6 U18.B7(SPI0_CS1)
SPI0_D0: J6.12 U18.A8(SPI0_D0)
SPI0_D1: J6.14 U18.C9(SPI0_D1)
SPI3_CLK: J1.13 U18.N3(PRG0_PRU0_GPO16)
SPI3_CS0: J2.6 U18.E1(PRG0_PRU0_GPO17)
SPI3_CS1: J2.18 U18.N4(PRG0_PRU0_GPO15)
SPI3_D0: J2.12 U18.N1(PRG0_PRU0_GPO13)
SPI3_D1: J2.14 U18.N2(PRG0_PRU0_GPO14)
SYNC1_OUT: J5.3 U18.A18(EXT_REFCLK1)
SYNC2_OUT: J1.18 R140.2
SYNC3_OUT: J1.20 R131.2
SYS_BOOTMODE3: R16.1 SW4.1 U4.3(A1) U26.2(P0)
SYS_BOOTMODE4: R27.1 SW4.2 U4.4(A2) U26.3(P1)
SYS_BOOTMODE5: R33.1 SW4.3 U4.5(A3) U26.4(P2)
SYS_BOOTMODE6: R47.1 SW4.4 U4.6(A4) U26.5(P3)
SYS_BOOTMODE7: R52.1 SW4.5 U4.7(A5) U26.7(P4)
SYS_BOOTMODE8: R66.1 SW4.6 U4.8(A6) U26.8(P5)
SYS_BOOTMODE9: R69.1 SW4.7 U4.9(A7) U26.9(P6)
TA_BOOTMODE_I2C_SCL: J15.37 R186.2 U26.12(SCL)
TA_BOOTMODE_I2C_SDA: J15.39 R178.2 U26.13(SDA)
TA_GPIO2: J15.31 R197.1 TP6.1(TP)
TA_GPIO3: J15.32 R196.1 TP3.1(TP) U28.1(A)
TA_GPIO4: J15.33 R189.1 U26.1(R\E\S\E\T\)
TA_PORZN: J15.27 Q8.3(G) R211.1
TA_POWERDOWN: J15.26 R84.1
TA_PWR_EN: R251.2 U41.3(EN)
TA_SOC_INTN: J15.30 Q16.3(G) R202.1
TA_WARMRESETN: J15.28 Q7.3(G) R209.1
TCA6408_EXP_ADDR: R177.2 U26.16(ADDR)
TCA6408_EXP_INT: R191.1 U26.11(I\N\T\)
TEST_LED1_GREEN: Q6.3(G) R173.2 R216.1 U18.U19(GPMC0_AD7)
TEST_LED2_RED: Q5.3(G) R172.2 U18.A9(UART0_RTSN)
TEST_LED3_RED: Q9.3(G) R174.2 U18.D1(PRG0_PRU1_GPO18)
TEST_LED4_GREEN: Q4.3(G) R165.2 U18.F3(PRG0_PRU1_GPO19)
TIMER_IO0: J6.1 R193.1 U18.K18(MMC1_DAT3)
TIMER_IO1: J6.3 R19.1 U18.K20(MMC1_DAT2)
TIMER_IO2: J6.5 R192.1 U18.J19(MMC1_DAT1)
TIMER_IO3: J6.7 R194.1 U18.J18(MMC1_DAT0)
TIMER_IO4: J6.9 R20.1
TIMER_IO4_R: R20.2 U18.J20(MMC1_CLK)
TIMER_IO5: J6.11 R21.1 U18.J21(MMC1_CMD)
TM4C129_TCK: TP18.1(TP) U37.100(PC0/TCK/SWCLK)
TM4C129_TDI: TP16.1(TP) U37.98(PC2/TDI)
TM4C129_TDO: TP15.1(TP) U37.97(PC3/TDO/SWO)
TM4C129_TMS: TP17.1(TP) U37.99(PC1/TMS/SWDIO)
TUSB_ADDR: TP29.1(TP) U20.5(ADDR)
TUSB_ID: TP28.1(TP) U20.9(ID)
TUSB_INT_N: R110.1 U20.6(INT_N/OUT3)
TUSB_OUT1: R107.1 U15.2(B)
TUSB_OUT1_R: R106.1 R107.2 U20.7(SDA/OUT1)
TUSB_OUT2: R92.2 R104.1 U15.1(A)
TUSB_OUT2_R: R104.2 R105.1 U20.8(SCL/OUT2)
TYPEC_CC1: J10.A5(CC1) U20.1(CC1)
TYPEC_CC2: J10.B5(CC2) U20.2(CC2)
TYPEC_DN: D6.1(CATHODE) J10.A7(DN1) J10.B7(DN2) L3.2(IN2)
TYPEC_DP: D7.1(CATHODE) J10.A6(DP1) J10.B6(DP2) L3.3(OUT1)
UART0_HDR_CTS#: J17.2 U8.6(2B)
UART0_HDR_RTS#: J17.6 U8.12(4A)
UART0_HDR_RXD: J17.5 U8.3(1B)
UART0_HDR_TXD: J17.4 U8.9(3A)
UART1_HDR_CTS#: J13.2 U12.6(2B)
UART1_HDR_RTS#: J13.6 U12.12(4A)
UART1_HDR_RXD: J13.5 U12.3(1B)
UART1_HDR_TXD: J13.4 U12.9(3A)
USB0_DN: L3.1(IN1) U18.AA17(USB0_DM)
USB0_DP: L3.4(OUT2) U18.AA16(USB0_DP)
USB0_DRVVBUS: TP21.1(TP) U18.B19(USB0_DRVVBUS)
USB0_ID: R83.2 U18.Y17(USB0_ID)
USB0_RCALIB: R239.1 U18.W17(USB0_RCALIB)
USB0_VBUS: R116.2 R118.2 U18.V18(USB0_VBUS)
USBC_SHIELD: C266.1 J10.SH1 J10.SH2 J10.SH3 J10.SH4 J10.SH5 J10.SH6 R160.1
USER_INTN: TP12.1(TP) U13.5(2Y) U18.B9(UART0_CTSN)
USER_LED1: Q2.3(G) R38.2 R61.1 U18.W20(GPMC0_AD11)
USER_LED2: Q1.3(G) R14.2 R62.1 U18.Y20(GPMC0_AD12)
VMON_MRN: C79.1 D5.1(CATHODE) Q8.1(S1) Q8.2(S2) Q8.5(S3) Q8.6(S4) Q8.8(S5) R171.1 SW1.1 SW1.3 U27.1(M\R\)
VMON_VSYS: C232.1 R255.1 R262.2 U18.G13(VMON_VSYS)
VPP_1V8: C38.1 TP51.1(TP) U14.5(OUT) U18.E16(VPP)
VPP_1V8_REG_EN: R90.2 U14.3(EN) U18.Y13(PRG1_PRU0_GPO8)
VSYS_3V3: C3.2 C6.1 C7.1 C8.1 C9.2 C10.1 C12.1 C13.1 C14.1 C15.1 C16.2 C21.1 C22.1 C24.1 C27.1 C29.1 C32.1 C37.1 C40.1 C41.1 C43.1 C45.1 C46.1 C54.1 C59.1 C74.1 C84.1 C86.1 C87.1 C90.1 C93.1 C94.1 C103.1 C106.1 C112.2 C119.1 C122.1 C124.1 C152.1 C159.1 C166.1 C207.1 C209.1 C218.1 C219.1 C220.1 C248.1 C258.1 C259.1 C265.2 C268.1 C270.1 FB3.1 FB4.1 J1.1 J14.1 J16.10 R1.2 R3.2 R4.2 R5.2 R7.1 R10.2 R12.1 R18.1 R32.2 R35.1 R36.2 R37.2 R39.2 R40.2 R41.2 R43.2 R44.2 R45.2 R68.1 R73.1 R79.1 R80.1 R82.1 R88.1 R89.2 R91.1 R95.1 R112.2 R129.1 R134.1 R135.1 R136.1 R163.1 R164.2 R166.1 R167.1 R168.1 R169.1 R170.2 R181.2 R183.2 R201.2 R210.1 R218.1 R220.2 R223.2 R224.2 R225.1 R226.1 R227.1 R229.1 R230.1 R236.2 R237.1 R238.1 R252.2 R254.1 R257.2 R258.1 R261.1 R264.1 R265.1 R266.1 R268.1 R269.1 R275.2 R282.1 R283.1 R284.1 R285.1 R588.2 R590.2 TP7.1(TP) U2.2(VCC) U3.4(VDD) U4.23(VCCB1) U4.24(VCCB2) U5.6(IN) U6.6(VDD) U7.18(VDDIO#18) U7.30(VDDIO#30) U8.14(VCC) U9.1(VCCA) U12.14(VCC) U13.8(VCC) U16.3(VCCA) U16.6(OE) U17.8(VCC) U19.18(VDDIO#18) U19.30(VDDIO#30) U22.10(VCC) U25.1(VCCA) U29.5(VCC) U30.10(VCC) U31.5(VCC) U32.1(VCCA) U32.23(VCCB1) U32.24(VCCB2) U33.1(IN1) U33.2(IN2) U33.5(EN) U34.5(VCC) U35.1(VCC) U39.1(IN1) U39.2(IN2) U39.4(BIAS) U40.1(VCC#1) U40.8(EN) U40.17(VCC#17) U40.30(VCC#30) U42.1(VCCA) U43.5(VCC) U44.5(NC/VIO) U45.1(VCCA) U45.2(1DIR) U46.2(VCCA) U46.8(OE)
VSYS_3V3_CT: C81.1 U27.4(CT2)
VSYS_3V3_FB: C40.2 R77.1 R80.2 U10.2(FB)
VSYS_3V3_R: C26.1 L1.2 R35.2
VSYS_3V3_SENSE: R195.1 R201.1 U27.9(SENSE2)
VSYS_3V3_SW: L1.1 U10.6(SW)
VSYS_5V0: C25.1 C39.1 C51.1 C63.1 C64.1 C91.1 C123.1 C269.1 J1.2 J9.1 J12.4 J21.4 R11.1 R85.2 R86.1 R117.1 R161.2 R171.2 R188.1 R211.2 R262.1 R270.1 R272.1 R273.1 R274.1 R279.1 R280.1 R281.1 TP39.1(TP) U10.7(VIN) U14.1(IN) U21.7(VIN) U23.7(VOUT1) U23.8(VOUT2) U27.14(VDD) U33.4(BIAS) U46.15(VCCB)
VSYS_5V0_CT: C69.1 U23.6(CT)
VSYS_5V0_ON: LD9.1(CATHODE) U15.4(Y) U23.3(ON)
VUSB_5V0: C42.1 C57.1 C65.1 C66.1 C67.1 C226.1 FL1.2 R94.1 R105.2 R106.2 R110.2 R113.2 R251.1 TP53.1(TP) U15.5(VCC) U20.12(VDD) U23.1(VIN1) U23.2(VIN2) U23.4(VBIAS) U41.1(IN)
WDI: R9.2 U27.20(WDI)
WDO: R11.2 U27.19(WDO)
XDS110_DEBUG_ID4: R98.1 U37.63(PK4)
XDS110_DEBUG_ID5: R99.1 U37.62(PK5)
XDS110_DEBUG_ID6: R100.1 U37.61(PK6)
XDS110_DEBUG_ID7: R101.1 U37.60(PK7)
XDS110_EMU0: R109.1 U16.8(B1) U37.42(PF0)
XDS110_EMU1: R108.1 U16.1(B2) U37.43(PF1)
XDS110_PROG_STAZ1: R114.2 U37.4(PD3/AIN12)
XDS110_PROG_STAZ2: R111.2 U37.3(PD2/AIN13)
XDS110_TCK: U25.13(1B1) U37.35(PA2/SSI0CLK)
XDS110_TDI: U25.12(1B2) U37.38(PA5/SSI0XDAT1)
XDS110_TDO: U37.37(PA4/SSI0XDAT0) U42.7(B1)
XDS110_TMS: U25.11(2B1) U37.36(PA3/SSI0FSS)
XDS110_TRST#: U25.10(2B2) U37.40(PA6)
XDS110_UART1_RXD: U37.33(PA0/U0RX) U45.13(1B1)
XDS110_UART1_TXD: U37.34(PA1/U0TX) U45.11(2B1)
XDS110_VBUS_DET: R212.1 R219.2 U37.1(PD0/AIN15)
XDS_RBIAS: R256.1 U37.59(RBAIS)
XDS_RESET#: R246.2 TP26.1(TP) U37.70(R\S\T\)
XDS_SHIELD: C263.1 J20.6(SH1) J20.7(SH2) J20.8(SH3) J20.9(SH4) R159.1
XDS_USB_D_N: J20.2(D-) U24.4(IO3) U24.7(NC2) U37.93(PL7/USB0DM)
XDS_USB_D_P: J20.3(D+) U24.5(IO4) U24.6(NC1) U37.94(PL6/USB0DP)
XDS_USB_ID: J20.4(ID) R231.2 U24.2(IO2) U24.9(NC3)
XDS_VREF: C128.1 C129.1 R235.2 U36.3(CATHODE) U37.9(VREFA+)
N17247526: LD15.2(ANODE) R282.2
N17247539: LD14.2(ANODE) R283.2
N17247599: LD13.2(ANODE) R284.2
N17247637: LD12.2(ANODE) R285.2
N29126233: R67.1 SW4.11
N29126235: R53.1 SW4.12
N29126237: R48.1 SW4.13
N29126239: R34.1 SW4.14
N29126243: R70.1 SW4.10
N29126245: R28.1 SW4.15
N29126269: R17.1 SW4.16
N30174920: R179.2 R180.2 U31.2(B)
N30212600: LD2.1(CATHODE) Q5.1(D1) Q5.2(D2) Q5.5(D3) Q5.6(D4) Q5.8(D5)
N30212640: LD1.2(ANODE) R167.2
N30212699: LD1.1(CATHODE) Q6.1(D1) Q6.2(D2) Q6.5(D3) Q6.6(D4) Q6.8(D5)
N30213674: LD2.2(ANODE) R166.2
N30217069: C114.1 R222.1 U37.96(PB1/USB0VBUS)
N30217074: R231.1 U37.95(PB0/USB0ID)
N30217111: LD10.2(ANODE) R111.1
N30217160: LD11.2(ANODE) R114.1
N30310219: D3.3(C) R117.2 R118.1
N30339679: R15.1 U1.1(A) U27.15(R\E\S\E\T\1\) U27.16(R\E\S\E\T\2\) U27.18(R\E\S\E\T\4\)
N30360253: TP25.1(TP) U19.13(VDDA1P8_1) U19.48(VDDA1P8_2)
N30371240: J19.14 R258.2
N30372374: C264.2 J19.12
N30372789: C261.2 J19.6
N30372794: C195.2 J19.1
N30372799: C164.2 J19.7
N30391563: J18.14 R210.2
N30391600: C127.2 J18.12
N30391628: C115.2 J18.6
N30391632: C89.2 J18.1
N30391636: C83.2 J18.7
N30391831: TP4.1(TP) U7.13(VDDA1P8_1) U7.48(VDDA1P8_2)
N30573184: LD6.2(ANODE) R79.2
N30625746: R271.2 U18.B5(TDO)
N30693218: LD3.3(A2) R168.2
N30693408: LD3.2(A1) R169.2
N30703604: LD7.2(ANODE) R86.2
N30743471: LD5.2(ANODE) R18.2
N30743502: LD5.1(CATHODE) Q2.1(D1) Q2.2(D2) Q2.5(D3) Q2.6(D4) Q2.8(D5)
N30743652: LD4.2(ANODE) R7.2
N30743676: LD4.1(CATHODE) Q1.1(D1) Q1.2(D2) Q1.5(D3) Q1.6(D4) Q1.8(D5)
N30811240: LD3.4(C2) Q9.1(D1) Q9.2(D2) Q9.5(D3) Q9.6(D4) Q9.8(D5)
N30811389: LD3.1(C1) Q4.1(D1) Q4.2(D2) Q4.5(D3) Q4.6(D4) Q4.8(D5)
N30900913: R240.1 R244.1 U18.A15(MCAN1_RX)
N30979572: R162.2 U25.4(1A1)
N31410611: LD8.2(ANODE) R91.2
N31410626: LD8.1(CATHODE) Q3.1(D1) Q3.2(D2) Q3.5(D3) Q3.6(D4) Q3.8(D5)
N31458583: R119.2 U20.3(PORT)
N31483389: LD9.2(ANODE) R94.2
N32041451: R31.2 U5.4(EN)

Pads without a net: D3 2; J10 A2 A3 A8 A10 A11 B2 B3 B8 B10 B11; J13 3; J15 4 5 6 8 9 10 11 12 13 14 15 17 18 19 20 21 22 23 24 29 35; J16 9; J17 3; SW4 8 9; U2 4 5 6 11 12 13 14; U4 14; U5 2; U6 7; U7 14 15 16 17 19 21 23 24; U10 4; U11 1; U14 4; U17 1; U18 H11 J13; U19 14 15 16 17 19 21 23 24; U21 4; U26 10; U27 3 11 13 17; U29 1; U35 11 12 13 14; U36 2 4 5; U37 2 5 6 11 12 13 14 15 18 19 20 21 22 23 24 25 27 29 30 31 32 41 44 45 46 49 50 53 54 56 57 65 67 71 72 73 74 75 76 77 78 81 82 83 84 85 86 91 92 102 103 104 105 106 107 108 109 110 111 112 116 117 118 119 120 121 123 124 125 126 127 128; U38 2 5; U39 3; U41 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 1397 vias
v2: diameter 0.406, hole 0.203, TOP to BOTTOM, 123 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0V85_EN: length 3.6
  TOP w0.254: U21.1 49.14,26.96 48.21,26.03 R127.2 48.23,25.5 R125.1
DGND: length 546.3
  TOP w0.102: v2(82.39,29.84) 81.89,30.34 U18.L10 ; U18.M15 82.39,32.84 v2(81.9,32.33) ; v2(80.89,28.82) 81.35,28.36 U18.K6 ; 80.94,29.36 81.39,28.9 U18.K7 ; v2(82.88,32.33) 83.39,32.84 U18.P15 ; v2(79.35,28.88) 79.35,28.82 U18.E6 ; U18.J11 80.94,30.86 v2(81.39,30.4) ; U18.R11 83.82,30.86 83.39,30.42 ; U18.K16 81.35,33.36 v2(80.89,32.9) 80.44,33.36 U18.H16 ; U18.D17 78.39,33.88 v2(78.9,34.38) ; U18.L11 81.94,30.86 v2(82.39,31.32) ; v2(79.93,29.39) 80.39,28.93 U18.H7 ; 82.91,30.86 v2(83.37,30.4)
  TOP w0.135: v1(44.2,43.43) 44.94,43.43 v1(44.96,43.45)
  TOP w0.152: U18.R6 84.01,28.47 84.01,28.47 84.3,28.76 v2(84.43,28.76) 84.5,28.76 U18.U6 ; U20.10 10.96,28.6 v1(10.21,28.6) 10.44,28.37 10.44,28.37 10.62,28.19 U20.11
  TOP w0.178: D4.2 74.92,12.22 74.6,12.22 v1(74.32,12.5)
  TOP w0.203: D2.2 26.89,60.36 v1(26.87,60.38) ; v1(76.76,38.21) 76.76,39.55 v1(76.56,39.75) ; 48.72,28.19 v1(49.91,28.19) 50.65,28.19 v1(50.66,28.2) 50.67,28.19 ; v1(75.83,38.21) 75.11,38.94 74.78,38.94 v1(74.27,39.45) ; v1(17.09,60.93) 17.1,60.94 D1.2
  TOP w0.254: U18.A20 U18.A21 U18.B21 ; v1(44.83,41.91) 44.43,42.32 U10.3 ; C57.2 8.74,28.12 v1(8.38,28.47) ; U18.P16 U18.P15 ; C58.2 v1(146.1,27.28) ; U18.P11 83.38,30.85 83.38,30.6 v2(83.37,30.4) 83.39,30.42 ; U4.11 v1(28.51,47.15) 28.51,47.51 28.65,47.65 U4.10 ; C19.2 132.82,47.69 v1(132.82,47.7) ; U18.E11 78.89,30.47 v2(78.83,30.4) ; U22.9 156.58,24.27 v1(156.57,24.26) ; C11.2 v1(146.1,49.33) ; U4.12 v1(30.34,45.8) ; v1(10.82,22.71) 10.82,22.66 10.59,22.42 10.17,22.42 9.91,22.17 9.86,22.17 9.85,22.16 U24.8 U24.3 ; U4.13 v1(31.84,45.8) ; U18.Y21 U18.AA21 U18.AA20 ; R54.2 68.73,46.5 v1(68.73,46.51) ; C23.2 v1(146.1,46.33) ; 22.44,19.05 21.95,19.05 21.27,18.37 J10.A12 ; C69.2 33.58,21.65 33.53,21.7 C63.2 ; U21.3 50.14,27.02 v1(50.53,26.64) ; U18.M16 U18.M15 ; C53.2 v1(146.1,30.28) ; C20.2 64.67,46.82 v1(64.75,46.74) ; U18.AA2 U18.AA1 U18.Y1 ; C17.2 v1(146.1,47.83) ; v1(132.84,48.82) 132.85,48.83 C14.2 ; U18.T14 84,32.36 v2(83.94,32.43) ; U18.B1 U18.A1 U18.A2 ; U25.15 68.74,23.98 68.96,24.2 v1(69.39,24.2) ; U18.N11 82.91,30.86 ; U13.4 60.26,37.86 v1(60.53,37.59) ; v2(82.88,32.33) 82.88,31.87 U18.N13 ; U18.J5 U18.J6 v2(80.89,28.82) ; v1(32.77,33.48) C45.2 32.17,34.08 32.11,34.14 U16.2 ; 32.03,21.82 32.04,21.83 U23.5 ; U22.5 154.6,22.77 v1(154.61,22.78) ; C61.2 137.51,22.6 137.31,22.4 v1(136.96,22.4) ; C55.2 v1(146.1,28.78) ; C64.2 34.47,21.72 v1(34.85,21.34) ; C15.2 58.1,48.79 v1(57.85,49.04) ; C34.2 137.51,41.65 137.33,41.47 137.05,41.47 v1(137.03,41.45) ; C59.2 v1(161.01,25.15) ; U10.5 45.85,44.11 v1(46.16,44.42) ; J10.A1 15.77,16.49 J10.B12 ; v1(51.88,29.18) 51.57,28.87 U21.5 ; v1(12.99,33.78) 12.6,34.18 12.6,34.87 12.78,35.06 U15.3 ; C70.2 22.33,19.81
  TOP w0.305: C60.2 69.14,24.82 69.39,24.57 v1(69.39,24.2) ; v2(80.9,29.39) 80.94,29.36 U18.K8 ; U18.H7 U18.H6 ; U18.D10 78.78,30.36 v2(78.83,30.4) ; U18.P7 83.35,28.82 v2(82.88,28.82) ; U18.L12 82.35,31.36 v2(82.39,31.32) ; U18.E13 U18.E11 ; U18.N6 82.89,28.81 v2(82.88,28.82) ; U18.G16 79.85,33.4 v2(79.38,33.4) 79.38,33.85 U18.F17 ; U18.M7 82.84,28.86 v2(82.88,28.82) ; U18.J16 v2(80.89,32.9) ; U18.D17 U18.D16 ; U18.F8 79.39,28.92 v2(79.35,28.88) ; v1(123.14,41.51) 122.74,41.91 C123.2
  TOP w0.33: C30.1 75.61,42.82 v1(75.49,42.7) ; C65.2 27.86,21.49 ; v1(141.96,54.61) 141.66,54.31 C6.2 ; U25.14 v1(69.39,24.2) ; v1(15.12,26.01) 15.12,26.02 R119.1 ; C54.2 v1(132.85,29.78) ; C4.2 v1(33.71,57.28) ; v1(57.61,30.38) 57.51,30.48 C49.2 ; v1(48.46,38.12) C39.2 49.05,37.24 R90.1 ; v1(54.99,37.74) 54.99,38.02 55.32,38.35 C38.2 ; C48.2 v1(56.62,30.35) ; R33.2 12.19,48.26 12.37,48.08 v1(12.8,48.08) ; v1(37.01,50.95) 36.6,50.55 R24.1 ; C46.2 v1(141.33,34.24) ; C10.2 84.21,49.63 C12.2 ; U5.5 60.43,48.9 v1(60.94,49.4) ; C42.2 15.57,36.78 v1(15.09,37.26) ; v1(30.38,55.19) 30.34,55.16 C5.2 ; C31.2 6.92,42.55 v1(7.01,42.45) ; C41.2 63.65,38.07 v1(63.75,38.18) ; C21.2 v1(51.03,45.59) ; C74.2 68.88,15.06 v1(69.01,15.19) ; v1(99.85,40.21) 99.84,40.2 C37.2 100.38,39.63 100.47,39.72 U12.13 ; U25.8 72.64,15.98 v1(72.64,15.98) ; C1.2 v1(20.5,59.84) ; v1(68.73,18.59) 68.74,18.59 U25.2 ; C13.2 v1(127.97,48.9) ; C29.2 v1(58.75,44.25) ; C2.2 v1(29.21,60.25) ; v1(35.69,53.16) 35.69,52.86 C8.2 ; C44.2 v1(25.76,35.26) ; C56.2 v1(132.85,28.64) ; C78.2 67.09,8.94 v1(67.26,8.94) ; C3.1 v1(99.47,56.85) ; C43.2 141.66,35.26 v1(141.96,35.56) ; v1(99.85,47.09) 99.84,47.09 C24.2 100.38,46.49 100.47,46.58 U8.13 ; U25.3 69.39,16.49 v1(69.75,16.13) ; C7.2 v1(141.33,53.29) ; C9.1 v1(113.16,51.82) ; C16.1 v1(127.97,48.01) ; R47.2 12.19,46.69 12.32,46.56 v1(12.8,46.56) ; U25.9 v1(72.64,24.2) ; C32.2 v1(8.41,42.55) ; U14.2 50.09,37.77 v1(49.78,37.47) ; C22.2 v1(51.92,45.59)
  TOP w0.381: v1(72.64,24.2) 71.73,25.11 R126.1 ; Q1.7 v1(3.69,54.22) ; R92.1 9.58,36.32 v1(9.07,35.81) ; U18.A1 76.89,25.51 76.89,25.5 v1(76.89,25.4) 76.78,25.4 v1(76.38,24.99) ; v1(99.85,40.21) 99.08,40.21 R83.1 ; v1(88.65,37.31) v1(88.11,36.78) 87.19,35.86 U18.AA21 ; Q3.7 v1(3.64,34.51) ; U8.4 v1(106.24,47.88) ; v1(37.86,30.61) D3.1 36.92,29.75 36.91,29.74 v1(36.91,29.72) ; R149.2 v1(51.84,19.13) ; U12.7 v1(108.9,42.97) ; C28.2 64.36,40.07 v1(64.38,40.06) ; v1(45.7,26.92) 45.7,25.85 R125.2 ; Q2.7 v1(3.69,48.12) ; U17.4 65.34,27.8 65.52,27.62 v1(65.56,27.62) ; C36.2 68.87,40.07 v1(68.89,40.06) ; R155.2 v1(60.07,19.13) ; U12.4 v1(106.24,41.02) ; U8.7 v1(108.9,49.83) ; U11.3 75.22,39.76 v1(75.21,39.75) ; R145.2 v1(46.35,19.13) ; v1(67.38,40.06) 66.7,40.06 C35.2 ; v1(38.49,27.77) R116.1 v1(39.27,28.55) ; v1(73,41.44) 73,41.43 R78.1 ; R9.1 12.05,58 v1(12.3,58.25) ; U18.AA1 87.2,25.56 v1(87.2,25.53) 87.22,25.53 v1(87.63,25.12) ; v1(77.67,38.4) v1(77.67,39.27) ; R142.2 v1(42.24,19.13) ; C33.2 65.2,40.06 v1(65.88,40.06) ; v1(11.43,45.77) 11.39,45.81 U9.4 ; R153.2 v1(57.33,19.13) ; U8.1 v1(106.24,45.93) ; U12.10 v1(100.44,41.67) ; Q1.4 v1(3.71,55.1) ; R151.2 v1(54.58,19.13) ; v1(73.23,39.65) 73.23,38.9 73.95,38.18 v1(74.52,38.18) 75.13,37.57 75.31,37.57 76.89,35.98 U18.A21 ; Q3.4 v1(3.64,35.39) ; Q2.4 v1(3.69,49) ; U12.1 v1(106.24,39.07) ; U1.2 v1(29.57,57.94) ; v1(73.15,37.72) 73.53,37.72 v1(73.81,37.44) ; R157.2 v1(62.81,19.13) ; U6.4 v1(117.69,47.54) ; R147.2 v1(49.1,19.13) ; U8.10 v1(100.44,48.53)
  TOP w0.508: R120.1 71.73,26.75 71.22,27.25 v1(70.99,27.25) ; C25.2 v1(46.16,44.42) ; R38.1 v1(4.57,49.25) ; v1(65.61,25.07) R122.1 R121.1 ; C77.2 v1(157.38,13.65) ; LD6.1 1.72,41.65 v1(1.73,41.66) ; v1(146.58,21.62) 146.58,21.69 146.59,21.7 R139.2 ; v1(132.21,45.19) 132.22,45.18 132.98,45.18 R64.2 ; C71.2 153,19.98 v1(153.9,19.98) ; v1(132.28,26.12) 132.29,26.14 132.57,26.13 132.98,26.13 R123.2 ; v1(84.2,51.31) 84.21,51.3 C10.2 ; v1(12.65,49.58) 12.64,49.58 12.6,49.63 12.6,49.63 12.19,50.04 R27.2 ; R16.2 12.19,51.54 12.6,51.13 12.6,51.12 v1(12.64,51.09) ; R87.1 v1(70.89,38.35) ; LD11.1 1.82,28.38 v1(1.78,28.42) ; v1(17.88,64.21) 18.05,64.38 SW2.2 ; v1(62.21,46.99) 63.18,46.99 C18.2 ; R14.1 v1(4.57,54.86) ; C75.2 153,13.63 v1(153.9,13.63) ; v1(11.43,45.77) 11.48,45.82 R52.2 ; U3.2 v1(114.18,47.74) ; C67.2 25.54,21.27 v1(25.55,21.29) ; R102.2 v1(146.56,31.78) ; C52.2 55.22,29.43 v1(54.97,29.18) ; R132.2 v1(133.2,21.64) ; R74.2 141.79,40.75 v1(141.43,40.39) ; v1(144.75,21.62) 144.75,21.69 144.76,21.7 R138.2 ; R72.2 v1(134.73,40.69) ; v1(51.88,29.18) C51.2 ; R75.2 v1(143.29,40.66) ; C76.2 v1(155.65,13.65) ; v1(34.47,64.26) 34.35,64.38 SW3.4 ; SW3.2 26.99,64.38 v1(26.57,63.96) ; R69.2 v1(11.43,42.82) ; SW1.4 17.06,64.38 v1(17.2,64.24) ; U14.2 52.43,37.77 v1(52.45,37.74) ; R22.2 v1(146.56,50.83) ; U2.10 v1(70.36,54.36) ; R71.2 v1(133.2,40.69) ; SW1.2 9.31,64.38 v1(9.25,64.31) ; LD10.1 1.83,29.37 v1(1.83,30.15) ; v1(75.97,8.38) 74.52,8.38 SW5.2 ; v1(25.93,64.21) 25.77,64.38 SW2.4 ; R137.2 143.29,21.7 143.28,21.69 v1(143.28,21.62) ; C50.2 v1(53.32,29.18) ; v1(1.73,39.62) 1.72,39.62 LD7.1 ; R49.1 v1(113.74,46.99) ; v1(67.82,8.38) 68.84,8.38 SW5.4 ; C73.2 v1(157.38,20) ; C26.2 v1(47.6,44.42) ; C47.2 v1(68.3,34.16) ; R133.2 v1(134.73,21.64) ; R128.1 v1(149.23,24.77) ; v1(49.26,44.42) 49.64,44.8 C27.2 ; C72.2 v1(155.65,20) ; R66.2 v1(11.43,44.32) ; R76.2 v1(145.01,40.66)
  L02_GND1 w0.254: J10.G2 J10.B1 ; J10.B12 J10.G1
  BOTTOM w0.135: 118.43,38.91 C124.2 119.78,38.91 ; 117.92,28.19 C220.2 119.27,28.19
  BOTTOM w0.152: v1(20.7,29.13) 20.7,27.99 U37.64 ; 17.86,35.59 17.95,35.49 U37.80 ; v1(17.14,22) 17.14,21.37 D7.2 ; 17.24,51.15 v1(16.94,50.85) ; D6.2 v1(18.76,22.01)
  BOTTOM w0.178: U37.58 23.1,29.13 v1(23.1,29.13) ; U42.5 65.98,19.77 65.7,20.05 v1(65.7,20.14) 65.73,20.17 U42.6 ; U42.4 68.44,19.78 v1(68.45,19.76) 68.45,19.97 68.25,20.17 U42.3 ; U37.114 27.5,42.24 v1(27.5,42.24) ; v1(24.3,29.13) 24.3,29.13 U37.55 24.3,27.05 23.74,26.48 23.74,25.71 R256.2 ; U30.5 v1(104.69,49.55) ; 18,29.89 U37.66 ; 27.27,26.43 27.1,26.6 U37.48 27.1,29.13 v1(27.1,29.13) ; U37.10 35.88,38.29 36.09,38.07 C129.2 ; v1(33.46,35.49) 33.46,35.49 U37.17 35.64,35.49 35.83,35.31
  BOTTOM w0.203: D5.2 9.28,63.37 v1(9.27,63.37) ; C196.2 83.79,30.02 83.41,30.4 v2(83.37,30.4)
  BOTTOM w0.254: C209.2 102.52,29.54 v1(102.51,29.54) ; C204.2 87.07,29.23 86.38,29.92 C203.2 ; C146.2 v1(9.07,35.81) ; C190.2 79.68,30.84 79.23,30.84 78.83,30.43 v2(78.83,30.4) 78.61,30.19 C202.2 ; Q6.7 v1(167.77,60.8) ; v1(96.27,50.99) C90.2 97.71,50.99 97.77,51.05 U30.9 ; C97.2 v1(132.82,47.7) ; C166.2 112.11,33.55 v1(112.47,33.91) ; J15.34 v1(7.01,51.45) ; C269.2 146.26,11.07 J12.5 ; Q7.7 24.29,60.4 v1(24.18,60.5) ; Q7.4 24.22,61.22 v1(24.18,61.26) ; U41.2 4.72,28.58 4.39,28.24 C226.2 3.81,28.45 4.06,28.7 4.11,28.7 v1(4.22,28.8) ; C210.2 78.97,28.5 78.81,28.34 77.26,28.34 C223.2 ; v1(137.03,41.45) 137.05,41.47 137.11,41.47 C113.2 ; v1(120.4,27.25) 119.87,27.78 C219.2 ; U26.6 v1(28.21,54.76) ; v1(15.34,31.12) 15.35,31.12 C182.2 ; J15.16 v1(7.01,42.45) ; Q4.4 182.31,64.22 v1(182.25,64.29) ; C91.2 v1(16.94,50.85) ; 27.27,26.43 27.27,25.83 27.02,25.58 C242.2 ; C198.2 82.7,29.84 v2(82.39,29.84) ; C104.2 27.56,45.8 27.64,45.71 C105.2 ; U45.15 35.58,18.82 ; U45.14 34.93,18.81 ; U45.7 32.33,15.77 ; C155.2 v1(9.07,34.92) ; C214.2 80.64,29.13 v2(80.9,29.39) 81.1,29.39 C215.2 ; v1(132.84,48.82) 133.4,48.82 C93.2 ; U46.9 143.73,14.87 v1(143.59,14.73) ; v1(16.97,28.85) 16.87,28.85 16.62,29.1 C208.2 17.55,29.44 18,29.89 ; U45.5 33.63,15.93 ; v1(112.32,24.9) 112.14,25.08 C248.2 ; C262.2 v1(38.11,18.25) ; C191.2 37.38,31.09 v1(37.86,30.61) ; Q9.7 v1(182.25,59.48) ; Q9.4 v1(182.25,60.36) ; v1(77.67,37.69) 78.13,37.24 C135.2 ; U45.10 32.33,18.81 v1(32.6,18.54) ; C270.2 v1(139.75,11.33) ; C192.2 77.29,31.43 77.69,31.83 C184.2 ; J15.40 v1(7.01,54.45) ; U45.8 31.68,15.81 ; U45.12 33.63,18.78 v1(33.87,18.54) ; v1(34.42,12.88) C268.2 35.05,12.88 35.05,13.24 34.93,13.36 U45.3 ; Q4.7 v1(182.25,63.34) ; U27.12 17.24,51.15 ; C181.2 16.38,31.7 v1(16.38,31.12) ; J15.7 v1(7.01,37.95) ; Q5.7 v1(172.6,60.8) ; C150.2 C149.2 ; Q5.4 v1(172.6,61.68) ; v1(5.16,46.94) 5.17,46.95 J15.25 ; Q6.4 v1(167.77,61.68) ; C169.2 C168.2
  BOTTOM w0.305: C185.2 83.87,32.36 v2(83.94,32.43) 83.99,32.38 84.61,32.38 84.89,32.65 C178.2 ; C210.2 v2(79.35,28.88) ; Q14.7 159.87,32.23 v1(159.84,32.26) 160.5,32.26 160.75,32.02 Q14.4 ; C187.2 82.32,31.24 v2(82.39,31.32) 82.47,31.24 C186.2 ; v1(164.89,41.57) Q11.4 Q11.7 ; C199.2 81.5,30.51 v2(81.39,30.4) 81.34,30.46 C200.2 80.92,31.23 C188.2 ; C145.2 85.17,35.51 84.89,35.24 84.89,34.63 C158.2 ; C227.2 80.48,27.89 80.83,28.23 80.83,28.25 80.89,28.32 v2(80.89,28.82) ; v1(161.48,28.64) Q15.4 Q15.7 ; C211.2 82.95,28.75 v2(82.88,28.82) 82.82,28.75 C212.2 ; Q13.7 Q13.4 v1(164.89,35.42) ; Q12.7 Q12.4 v1(164.89,38.7) ; v2(82.88,32.33) 83.15,32.33 C173.2 ; C172.2 81.65,32.33 v2(81.9,32.33) 82.14,32.33 C175.2 ; C201.2 79.91,29.41 v2(79.93,29.39) ; C169.2 75.32,34.18 ; Q10.7 Q10.4 v1(167.4,57.77)
  BOTTOM w0.33: v1(75.83,38.21) 75.62,38 C139.2 ; v1(96.57,48.16) 96.58,48.17 R203.1 ; C195.1 v1(178.05,30.35) ; v1(73.15,37.72) C142.2 ; C249.2 83.09,24.33 ; C259.2 69.39,21.36 v1(69.8,21.77) ; C88.2 34.17,54.58 TP2.1 ; U36.1 v1(39.41,37.32) ; C11.2 v1(146.1,49.33) ; C140.2 C133.2 85.93,37.67 v1(86.08,37.82) ; C140.2 85.85,36.78 ; C140.2 C145.2 85.67,35.86 85.95,36.14 ; C193.2 72.65,30.17 73.38,29.44 v1(73.58,29.44) 73.76,29.62 C194.2 ; C153.2 C144.2 C135.2 ; v1(143.28,21.62) 143.15,21.49 C258.2 ; C102.2 30.01,46.13 v1(30.34,45.8) ; C250.2 77.96,24.33 ; C122.2 120.88,38.76 v1(121.67,37.97) ; v1(87.63,25.12) 87.08,25.12 87.03,25.17 C246.2 ; C141.2 C134.2 83.06,37.8 v1(82.6,37.8) v1(82.6,38.46) ; C141.2 v1(82.6,36.78) 82.5,36.68 C150.2 ; C141.2 83.19,36.43 83.26,36.36 C149.2 ; 86.13,33.83 86.49,34.19 C157.2 87.48,34.19 87.59,34.08 C156.2 ; C147.2 80.08,36.17 80.08,36.57 80.08,36.58 80.08,36.94 79.96,37.06 v1(79.96,37.19) 79.91,37.19 79.45,36.73 C148.2 ; C251.2 81.99,24.26 ; C239.2 81.99,26.03 ; v1(76.76,38.21) 76.5,37.96 C138.2 C137.2 ; C224.2 74.02,28.14 73.52,27.65 v1(73.52,27.64) ; v1(146.96,25.76) 146.69,26.03 C238.2 146.01,26.58 146.1,26.67 v1(146.1,27.28) C58.2 ; C85.2 v1(21.31,53.95) ; C128.2 v1(37.57,37.52) ; C204.2 87.48,28.8 ; C170.2 10.9,33.29 11.39,33.78 v1(11.72,33.78) ; C244.2 77.96,25.24 ; C127.1 v1(175.66,38.41) ; U32.10 v1(117.59,51.12) ; v1(127.97,48.9) 128.76,48.9 129.3,49.43 U29.3 ; v1(123.56,51.05) 123.63,51.12 U32.15 ; C231.2 141.71,27.25 v1(141.2,27.76) ; v1(141.2,29.03) 141.46,28.78 C217.2 ; v1(29.46,25.73) 29.69,25.96 C240.2 ; U38.3 14.69,31.35 15.06,31.72 C182.2 C181.2 ; C174.2 80.68,33.12 v2(80.89,32.9) 80.89,33.9 C160.2 ; C229.2 127.98,27.49 v1(128.12,27.64) ; v1(37.01,50.95) 37.48,50.49 U28.3 ; C264.1 v1(175.65,16.84) ; U32.2 117.49,45.92 117.4,45.83 C103.2 v1(116.87,46.39) ; 83.09,25.22 C245.2 ; C96.2 141.46,47.83 v1(141.2,48.08) ; C94.2 76.3,48.36 v1(76.43,48.49) ; C130.2 v1(128.12,38.21) ; v1(74.83,34.57) 75.21,34.18 75.32,34.18 ; C192.2 76.93,30.82 C189.2 ; C261.1 v1(175.67,17.73) ; v1(64.06,21.03) 64.12,20.97 C260.2 ; C106.2 128.01,45.27 v1(128.02,45.26) ; v1(65.56,27.62) 65.3,27.37 C232.2 ; C119.2 v1(141.43,40.39) ; C112.1 v1(159.66,41.43) ; C247.2 81.99,25.1 ; C237.2 87,26.06 87.2,25.86 v1(87.2,25.53) ; 35.83,35.31 C151.2 v1(36.42,34.72) ; C55.2 v1(146.1,28.78) ; C89.1 v1(178.03,52.2) ; C228.2 132.85,27.75 v1(132.85,28.64) C56.2 ; C83.1 v1(171.94,56.26) ; v1(15.62,41.53) 15.62,41.71 16.05,42.14 C114.2 ; v1(15.09,37.26) 15.09,37.87 C131.1 ; C205.2 84.62,32.38 84.61,32.38 ; v1(16.59,35.59) C154.2 17.86,35.59 ; v2(84.43,28.76) 84.53,28.76 84.64,28.65 C213.2 ; C115.1 v1(175.64,39.32) ; C177.2 86.69,33.68 ; C129.2 v1(36.68,37.52) ; v1(73.86,34.57) 73.86,33.54 C171.2 74.66,33.43 74.66,33.43 C169.2 ; v2(78.9,34.38) 78.55,34.38 C162.2 ; v1(121.67,27.25) 120.88,28.04 C218.2 ; 88.11,33.55 88.11,33.39 87.6,32.88 C176.2 ; 72.82,25.44 73.6,25.44 73.63,25.47 73.68,25.47 C236.2 ; C163.2 79.4,33.42 v2(79.38,33.4) ; C234.2 77.96,26.16 ; C17.2 v1(146.1,47.83) ; C132.2 16.37,37.9 v1(16.26,38.01) ; v1(28.65,45.69) 28.63,45.71 C105.2 ; C167.2 C168.2 ; C253.2 83.11,23.42 ; C265.1 v1(167.36,17.6) ; C100.2 141.71,46.3 v1(141.2,46.81) ; v1(146.96,44.78) 146.66,45.09 C107.2 ; v1(164.04,21.41) 164.61,21.41 164.61,21.02 164.52,20.93 U44.2 ; C152.2 v1(141.96,35.56) ; C254.2 81.99,23.32 ; C53.2 v1(146.1,30.28) ; C87.2 v1(126.97,52.78) ; C206.2 88.65,28.24 ; C120.1 v1(15.09,40.39) ; C116.2 81.97,42.59 82.1,42.72 C109.2 ; C180.2 v1(37.42,32.11) ; C54.2 v1(132.85,29.78) ; C164.1 v1(171.94,34.41) ; C121.2 v1(37.8,39.5) ; C159.2 v1(141.33,34.24) ; C79.2 10.42,62.93 9.97,63.37 v1(9.27,63.37) ; v1(77.67,37.69) v1(77.67,38.4) ; C256.2 137.11,22.42 136.97,22.42 v1(136.96,22.4) 136.93,22.4 136.91,22.42 R267.2 ; C23.2 v1(146.1,46.33) ; C235.2 83.09,26.13 ; C86.2 v1(141.33,53.29)
  BOTTOM w0.381: R173.1 167.68,60.71 v1(167.77,60.8) ; R199.2 v1(18.21,47.93) ; v1(22.05,49.73) 22.28,49.97 R195.2 ; R241.1 v1(148.08,35.08) ; R591.1 92.61,38.45 v1(92.68,38.37) ; R592.2 33.45,10.46 v1(33.27,10.29) ; v1(182.25,59.48) 182.16,59.39 R174.1 ; v1(73.81,37.44) 73.82,37.45 C136.2 v1(74.52,38.18) ; v1(20.5,59.84) 20.15,60.19 C80.2 ; v1(89.71,28.32) v1(90.47,28.32) ; v1(63.65,9.04) 63.66,9.05 Q16.4 Q16.7 ; C156.2 88.11,33.55 ; R206.1 91.76,48.17 v1(92.05,47.88) ; C255.2 77.98,23.29 v1(77.19,22.5) ; R175.1 v1(22.28,59.07) ; v1(122.66,51.15) 123.28,51.77 U32.14 ; R234.1 72.82,40.06 v1(73.23,39.65) ; v1(73.52,27.64) 73.48,27.68 C225.2 ; R205.1 v1(95.07,48.17) R204.1 96.56,48.17 v1(96.57,48.16) ; R242.2 137.43,35.31 v1(137.41,35.33) ; C108.2 C110.2 67.62,44.57 v1(68.36,44.57) 69.1,44.57 C117.2 69.14,44.53 v1(69.85,44.53) ; v1(139.01,19.46) 139.01,19.43 139,19.42 U43.3 ; C82.2 v1(15.54,60.92) ; C81.2 17.32,60.71 v1(17.09,60.93) ; v1(119.13,37.97) 119.13,38.88 C124.2 ; v2(75.26,31.42) 75.46,31.22 C189.2 ; v1(137.03,41.45) 136.97,41.39 R228.2 ; U32.13 v1(122.66,52.42) ; v1(132.21,45.19) 132.21,44.56 132.99,43.78 R221.2 ; Q8.4 v1(11.47,58.24) ; v1(98.45,43) 97.04,43 R589.1 ; C143.2 81.83,37.28 82.35,37.8 v1(82.6,37.8) ; Q8.7 v1(12.3,58.25) ; v1(68.3,34.16) 69,34.16 C161.2 ; R165.1 182.11,63.48 v1(182.25,63.34) ; R212.2 16.33,46.96 v1(16.56,47.19) ; C98.2 132.82,46.83 v1(132.82,47.7) ; U35.8 159.88,33.66 159.94,33.72 R243.1 v1(161.48,33.72) ; R245.1 v1(148.08,33.55) ; R260.2 132.99,24.73 132.28,25.44 v1(132.28,26.12) ; v1(71.34,44.55) 70.62,44.55 C118.2 ; U32.12 v1(120.12,52.42) ; v1(172.6,60.8) 172.51,60.71 R172.1 ; R207.1 87.9,48.79 v1(87.81,48.79) 87.76,48.79 87.66,48.69 87.65,48.69 R208.1
  BOTTOM w0.508: R250.1 v1(113.01,27.9) ; U35.16 v1(151.03,42.54) ; R276.1 v1(161.13,17.41) ; C84.2 v1(141.96,54.61) ; C220.2 118.6,27.78 v1(119.13,27.25) ; v1(5.47,32.68) J15.41 v1(4.18,31.38) ; v1(138.46,38.84) 138.45,38.83 U34.3 ; v1(4.18,58.03) J15.42 v1(5.47,56.73) ; v1(128.12,28.91) 127.85,28.63 C222.2 ; v1(129.39,39.48) 129.39,39.9 128.91,40.38 R232.2 ; U31.3 v1(77.64,52.82) ; C267.2 v1(168.33,13.62) ; Y1.2 v1(14.38,37.89) ; R247.2 129.01,29.66 129.39,29.28 v1(129.39,28.91) ; C125.2 128,39.35 v1(128.12,39.48) ; C126.2 v1(77.67,39.27) ; R177.1 v1(20.51,55.26) ; C109.2 v1(83.11,43.46) ; Y1.4 v1(10.22,40.09) ; v1(7.62,25.1) 7.63,25.11 C243.2 v1(9.27,25.11) ; R184.2 v1(136.94,55.27) ; v1(65.61,25.07) 65.58,25.1 65.58,25.86 R255.2 ; v1(72.64,24.2) 72.82,24.39 C241.2 72.82,25.44 ; v1(91.31,33.8) v1(90.42,33.8) v1(89.41,33.8) 89.08,33.47 C179.2 ; v1(104.69,49.55) 105.3,50.16 R190.1
  vias: v1(1.55,43.94) v1(7.65,19.48) v1(8.92,19.48) v1(9.47,20.55) v1(10.13,13.18) v1(10.19,19.48) v1(10.21,9.83) v1(11.38,20.55) v1(12.99,32.51) v1(15.54,55.25) v1(15.54,54.1) v1(15.54,52.96) v1(16.69,55.25) v1(16.69,54.1) v1(16.69,52.96) v1(17.35,20.7) v1(17.83,55.25) v1(17.83,54.1) v1(17.83,52.96) v1(19.15,20.5) v1(20.37,38.1) v1(25.3,55.02) v1(25.3,54) v1(26.31,55.02) v1(26.31,54) v1(27.52,19.81) v1(27.52,18.54) v1(28.79,18.54) v1(28.79,17.27) v1(30.06,18.54) v1(30.06,17.27) v1(30.46,50.93) v1(30.46,49.4) v1(30.46,47.88) v1(30.94,21.06) v1(30.94,20.29) v1(30.96,23.55) v1(30.96,22.4) v1(31.33,18.54) v1(31.33,17.27) v1(31.73,50.93) v1(31.73,49.4) v1(31.73,47.88) v1(32.6,17.27) v1(33.87,17.27) v1(36.96,58.27) v1(37.08,10.41) v1(37.57,63.73) v1(39.98,42.85) v1(39.98,41.58) v1(40.11,63.73) v1(41.25,42.85) v1(41.25,41.58) v1(42.65,63.73) v1(45.19,63.73) v1(45.7,28.19) v1(46.16,43.15) v1(46.16,41.88) v1(46.97,28.19) v1(46.97,26.92) v1(47.19,8.51) v1(47.6,43.15) v1(47.6,41.88) v1(47.73,63.73) v1(49.26,43.15) v1(49.26,41.88) v1(50.27,63.73) v1(50.53,44.42) v1(50.53,43.15) v1(50.53,41.88) v1(51.8,44.42) v1(51.8,43.15) v1(51.8,41.88) v1(51.88,27.91) v1(52.02,26.49) v1(53.07,44.42) v1(53.07,43.15) v1(53.07,41.88) v1(53.32,27.91) v1(53.32,26.64) v1(53.72,37.74) v1(53.95,8.64) v1(54.97,27.91) v1(54.97,26.64) v1(56.24,29.18) v1(56.24,27.91) v1(56.24,26.64) v1(57.51,29.18) v1(57.51,27.91) v1(57.51,26.64) v1(58.78,29.18) v1(58.78,27.91) v1(58.78,26.64) v1(59.79,26.38) v1(60.55,8.69) v1(60.94,48.39) v1(60.94,46.99) v1(60.94,45.47) v1(61.29,26.64) v1(62.21,45.47) v1(62.79,26.49) v1(63.48,45.47) v1(64.75,45.47) v1(66.02,46.74) v1(66.02,45.47) v1(76.78,9.07) v1(78.08,22.56) v1(82.63,23.7) v1(82.63,22.68) v1(84.89,8.97) v1(86.08,38.86) v1(88.42,38.66) v1(90.53,14.5) v1(94.1,36.28) v1(94.11,34.98) v1(94.13,14.4) v1(95.91,36.26) v1(98.2,56.85) v1(98.2,55.58) v1(99.47,55.58) v1(107.29,32.56) v1(107.29,31.29) v1(107.29,30.02) v1(107.29,28.75) v1(107.29,27.48) v1(107.29,26.21) v1(108.56,32.56) v1(108.56,31.29) v1(108.56,30.02) v1(108.56,28.75) v1(108.56,27.48) v1(108.56,26.21) v1(116.59,37.97) v1(116.59,36.7) v1(116.59,27.25) v1(116.59,25.98) v1(117.86,37.97) v1(117.86,36.7) v1(117.86,27.25) v1(117.86,25.98) v1(119.13,36.7) v1(119.13,25.98) v1(120.02,51.16) v1(120.4,37.97) v1(120.4,36.7) v1(120.4,25.98) v1(121.39,52.42) v1(121.39,51.15) v1(121.67,36.7) v1(121.67,25.98) v1(122.94,37.97) v1(122.94,36.7) v1(122.94,27.25) v1(122.94,25.98) v1(123.14,42.4) v1(123.14,40.62) v1(123.14,31.68) v1(123.14,30.79) v1(123.14,29.9) v1(124.03,42.4) v1(124.03,41.51) v1(124.03,40.62) v1(124.03,31.68) v1(124.03,30.79) v1(124.03,29.9) v1(125.55,43.54) v1(125.55,32.82) v1(126.44,43.54) v1(126.44,32.82) v1(128.12,36.94) v1(128.12,26.37) v1(129.39,38.21) v1(129.39,36.94) v1(129.39,27.64) v1(129.39,26.37) v1(138.66,49.35) v1(138.66,48.08) v1(138.66,46.81) v1(138.66,30.3) v1(138.66,29.03) v1(138.66,27.76) v1(139.93,49.35) v1(139.93,48.08) v1(139.93,46.81) v1(139.93,30.3) v1(139.93,29.03) v1(139.93,27.76) v1(141.2,49.35) v1(141.2,30.3) v1(142.32,14.73) v1(142.32,13.72) v1(142.32,12.7) v1(143.59,13.72) v1(143.59,12.7) v1(150.04,40.77) v1(150.04,38.23) v1(156.95,57.53) v1(159.49,57.53) v1(162.03,57.53) v1(163.83,19.38) v1(163.83,18.11) v1(164.85,19.38) v1(164.85,18.11) v1(165.86,19.38) v1(165.86,18.11) v1(188.54,49.63) v1(188.54,48.36) v1(188.54,47.09) v1(188.54,45.82) v1(188.54,44.55) v1(188.54,27.79) v1(188.54,26.52) v1(188.54,25.25) v1(188.54,23.98) v1(188.54,22.71) v1(189.81,49.63) v1(189.81,48.36) v1(189.81,27.79) v1(189.81,26.52)
